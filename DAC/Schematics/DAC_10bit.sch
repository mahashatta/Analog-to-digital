v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -3675287.5 -24692457.5 -3675275 -24692457.5 { lab=In1}
N -3675287.5 -24692362.5 -3675275 -24692362.5 { lab=D1}
N -3675287.5 -24692350 -3675275 -24692350 { lab=D0}
N -3675562.5 -24692417.5 -3675562.5 -24692405 { lab=In1}
N -3675562.5 -24692345 -3675562.5 -24692325 { lab=vref1}
N -3675562.5 -24692325 -3675562.5 -24692322.5 { lab=vref1}
N -3675562.5 -24692262.5 -3675562.5 -24692245 { lab=vref1}
N -3675562.5 -24692245 -3675562.5 -24692235 { lab=vref1}
N -3675562.5 -24692175 -3675562.5 -24692157.5 { lab=In2}
N -3675287.5 -24692337.5 -3675275 -24692337.5 { lab=vref1}
N -3675150 -24692512.5 -3675150 -24692500 { lab=Vdd}
N -3675022.5 -24692395 -3674972.5 -24692395 { lab=#net1}
N -3674970 -24692322.5 -3674905 -24692322.5 { lab=#net1}
N -3674970 -24692395 -3674970 -24692322.5 { lab=#net1}
N -3674972.5 -24692395 -3674970 -24692395 { lab=#net1}
N -3674970 -24692227.5 -3674905 -24692227.5 { lab=#net2}
N -3674970 -24692227.5 -3674970 -24692150 { lab=#net2}
N -3674977.5 -24692150 -3674970 -24692150 { lab=#net2}
N -3674780 -24692405 -3674780 -24692395 { lab=Vdd}
N -3674667.5 -24692280 -3674655 -24692280 { lab=out}
N -3674770 -24692182.5 -3674770 -24692170 { lab=D9}
N -3675562.5 -24692322.5 -3675562.5 -24692265 { lab=vref1}
N -3675562.5 -24692265 -3675562.5 -24692262.5 { lab=vref1}
N -3675287.5 -24692375 -3675275 -24692375 { lab=D2}
N -3675287.5 -24692400 -3675275 -24692400 { lab=D4}
N -3675022.5 -24692150 -3674977.5 -24692150 { lab=#net2}
N -3675287.5 -24692387.5 -3675275 -24692387.5 { lab=D3}
N -3675287.5 -24692412.5 -3675275 -24692412.5 { lab=D5}
N -3675287.5 -24692425 -3675275 -24692425 { lab=D6}
N -3675287.5 -24692437.5 -3675275 -24692437.5 { lab=D7}
N -3675287.5 -24692212.5 -3675275 -24692212.5 { lab=vref1}
N -3675287.5 -24692117.5 -3675275 -24692117.5 { lab=D1}
N -3675287.5 -24692105 -3675275 -24692105 { lab=D0}
N -3675287.5 -24692092.5 -3675275 -24692092.5 { lab=In2}
N -3675150 -24692267.5 -3675150 -24692255 { lab=Vdd}
N -3675287.5 -24692130 -3675275 -24692130 { lab=D2}
N -3675287.5 -24692155 -3675275 -24692155 { lab=D4}
N -3675287.5 -24692142.5 -3675275 -24692142.5 { lab=D3}
N -3675287.5 -24692167.5 -3675275 -24692167.5 { lab=D5}
N -3675287.5 -24692180 -3675275 -24692180 { lab=D6}
N -3675287.5 -24692192.5 -3675275 -24692192.5 { lab=D7}
N -3675287.5 -24692447.5 -3675275 -24692447.5 { lab=D8}
N -3675287.5 -24692202.5 -3675275 -24692202.5 { lab=D8}
C {devices/res.sym} -3675562.5 -24692375 0 0 {name=R8
value=250
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} -3675287.5 -24692457.5 0 0 {name=l12 sig_type=std_logic lab=In1}
C {devices/lab_pin.sym} -3675150 -24692512.5 2 0 {name=l14 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -3674780 -24692405 2 0 {name=l15 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -3675287.5 -24692350 0 0 {name=l23 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -3675287.5 -24692362.5 0 0 {name=l24 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -3674655 -24692280 2 0 {name=l25 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} -3675562.5 -24692417.5 0 0 {name=l7 sig_type=std_logic lab=In1}
C {devices/res.sym} -3675562.5 -24692205 0 0 {name=R6
value=250
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} -3675562.5 -24692157.5 0 0 {name=l9 sig_type=std_logic lab=In2}
C {devices/lab_pin.sym} -3675562.5 -24692332.5 0 0 {name=l10 sig_type=std_logic lab=vref1}
C {devices/lab_pin.sym} -3675287.5 -24692337.5 0 0 {name=l11 sig_type=std_logic lab=vref1}
C {TG.sym} -3674900 -24690835 0 0 {name=x3}
C {devices/lab_pin.sym} -3674770 -24692170 0 0 {name=l1 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} -3675287.5 -24692375 0 0 {name=l2 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -3675287.5 -24692400 0 0 {name=l8 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -3675287.5 -24692387.5 0 0 {name=l17 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -3675287.5 -24692092.5 0 0 {name=l13 sig_type=std_logic lab=In2}
C {devices/lab_pin.sym} -3675287.5 -24692412.5 0 0 {name=l3 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -3675287.5 -24692425 0 0 {name=l4 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -3675287.5 -24692212.5 0 0 {name=l5 sig_type=std_logic lab=vref1}
C {devices/lab_pin.sym} -3675287.5 -24692437.5 0 0 {name=l19 sig_type=std_logic lab=D7}
C {DAC_9bit.sym} -2518837.5 -16554917.5 0 0 {name=x1}
C {devices/lab_pin.sym} -3675150 -24692267.5 2 0 {name=l16 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -3675287.5 -24692105 0 0 {name=l18 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -3675287.5 -24692117.5 0 0 {name=l20 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -3675287.5 -24692130 0 0 {name=l22 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -3675287.5 -24692155 0 0 {name=l26 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -3675287.5 -24692142.5 0 0 {name=l27 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -3675287.5 -24692167.5 0 0 {name=l28 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -3675287.5 -24692180 0 0 {name=l29 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -3675287.5 -24692192.5 0 0 {name=l30 sig_type=std_logic lab=D7}
C {DAC_9bit.sym} -2518837.5 -16554672.5 0 0 {name=x2}
C {devices/lab_pin.sym} -3675287.5 -24692447.5 0 0 {name=l6 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -3675287.5 -24692202.5 0 0 {name=l21 sig_type=std_logic lab=D8}
