v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -375 -3552.5 -375 -3547.5 { lab=GND}
N -375 -3570 -375 -3552.5 { lab=GND}
N -505 -3692.5 -492.5 -3692.5 { lab=A}
N -505 -3622.5 -492.5 -3622.5 { lab=B1}
N -375 -3572.5 -375 -3570 { lab=GND}
N -272.5 -3662.5 -257.5 -3662.5 { lab=Q1}
N -490 -3960 -490 -3950 { lab=GND}
N -962.5 -3805 -962.5 -3795 { lab=GND}
N -1182.5 -3805 -1182.5 -3795 { lab=GND}
N -1182.5 -3885 -1182.5 -3865 { lab=clk}
N -962.5 -3885 -962.5 -3865 { lab=A}
N -490 -4040 -490 -4020 { lab=B8}
N -402.5 -3960 -402.5 -3950 { lab=GND}
N -402.5 -4040 -402.5 -4020 { lab=B7}
N -322.5 -3960 -322.5 -3950 { lab=GND}
N -322.5 -4040 -322.5 -4020 { lab=B6}
N -237.5 -3957.5 -237.5 -3947.5 { lab=GND}
N -237.5 -4037.5 -237.5 -4017.5 { lab=B5}
N -160 -3955 -160 -3945 { lab=GND}
N -160 -4035 -160 -4015 { lab=B4}
N -72.5 -3955 -72.5 -3945 { lab=GND}
N -72.5 -4035 -72.5 -4015 { lab=B3}
N 7.5 -3955 7.5 -3945 { lab=GND}
N 7.5 -4035 7.5 -4015 { lab=B2}
N 92.5 -3952.5 92.5 -3942.5 { lab=GND}
N 92.5 -4032.5 92.5 -4012.5 { lab=B1}
N -1352.5 -3817.5 -1352.5 -3807.5 { lab=GND}
N -1352.5 -3897.5 -1352.5 -3877.5 { lab=VDD}
N -382.5 -3772.5 -382.5 -3757.5 { lab=VDD}
N -505 -3660 -492.5 -3660 { lab=clk}
N -377.5 -3547.5 -377.5 -3530 { lab=GND}
N -377.5 -3547.5 -375 -3547.5 { lab=GND}
N -372.5 -3262.5 -372.5 -3257.5 { lab=GND}
N -372.5 -3280 -372.5 -3262.5 { lab=GND}
N -502.5 -3402.5 -490 -3402.5 { lab=A}
N -502.5 -3332.5 -490 -3332.5 { lab=B2}
N -372.5 -3282.5 -372.5 -3280 { lab=GND}
N -270 -3372.5 -255 -3372.5 { lab=Q2}
N -380 -3482.5 -380 -3467.5 { lab=VDD}
N -502.5 -3370 -490 -3370 { lab=clk}
N -375 -3257.5 -375 -3240 { lab=GND}
N -375 -3257.5 -372.5 -3257.5 { lab=GND}
N -365 -2970 -365 -2965 { lab=GND}
N -365 -2987.5 -365 -2970 { lab=GND}
N -495 -3110 -482.5 -3110 { lab=A}
N -495 -3040 -482.5 -3040 { lab=B3}
N -365 -2990 -365 -2987.5 { lab=GND}
N -262.5 -3080 -247.5 -3080 { lab=Q3}
N -372.5 -3190 -372.5 -3175 { lab=VDD}
N -495 -3077.5 -482.5 -3077.5 { lab=clk}
N -367.5 -2965 -367.5 -2947.5 { lab=GND}
N -367.5 -2965 -365 -2965 { lab=GND}
N -367.5 -2652.5 -367.5 -2647.5 { lab=GND}
N -367.5 -2670 -367.5 -2652.5 { lab=GND}
N -497.5 -2792.5 -485 -2792.5 { lab=A}
N -497.5 -2722.5 -485 -2722.5 { lab=B4}
N -367.5 -2672.5 -367.5 -2670 { lab=GND}
N -265 -2762.5 -250 -2762.5 { lab=Q4}
N -375 -2872.5 -375 -2857.5 { lab=VDD}
N -497.5 -2760 -485 -2760 { lab=clk}
N -370 -2647.5 -370 -2630 { lab=GND}
N -370 -2647.5 -367.5 -2647.5 { lab=GND}
N -367.5 -2337.5 -367.5 -2332.5 { lab=GND}
N -367.5 -2355 -367.5 -2337.5 { lab=GND}
N -497.5 -2477.5 -485 -2477.5 { lab=A}
N -497.5 -2407.5 -485 -2407.5 { lab=B5}
N -367.5 -2357.5 -367.5 -2355 { lab=GND}
N -265 -2447.5 -250 -2447.5 { lab=Q5}
N -375 -2557.5 -375 -2542.5 { lab=VDD}
N -497.5 -2445 -485 -2445 { lab=clk}
N -370 -2332.5 -370 -2315 { lab=GND}
N -370 -2332.5 -367.5 -2332.5 { lab=GND}
N -360 -2017.5 -360 -2012.5 { lab=GND}
N -360 -2035 -360 -2017.5 { lab=GND}
N -490 -2157.5 -477.5 -2157.5 { lab=A}
N -490 -2087.5 -477.5 -2087.5 { lab=B6}
N -360 -2037.5 -360 -2035 { lab=GND}
N -257.5 -2127.5 -242.5 -2127.5 { lab=Q6}
N -367.5 -2237.5 -367.5 -2222.5 { lab=VDD}
N -490 -2125 -477.5 -2125 { lab=clk}
N -362.5 -2012.5 -362.5 -1995 { lab=GND}
N -362.5 -2012.5 -360 -2012.5 { lab=GND}
N -350 -1700 -350 -1695 { lab=GND}
N -350 -1717.5 -350 -1700 { lab=GND}
N -480 -1840 -467.5 -1840 { lab=A}
N -480 -1770 -467.5 -1770 { lab=B7}
N -350 -1720 -350 -1717.5 { lab=GND}
N -247.5 -1810 -232.5 -1810 { lab=Q7}
N -357.5 -1920 -357.5 -1905 { lab=VDD}
N -480 -1807.5 -467.5 -1807.5 { lab=clk}
N -352.5 -1695 -352.5 -1677.5 { lab=GND}
N -352.5 -1695 -350 -1695 { lab=GND}
N -350 -1402.5 -350 -1397.5 { lab=GND}
N -350 -1420 -350 -1402.5 { lab=GND}
N -480 -1542.5 -467.5 -1542.5 { lab=A}
N -480 -1472.5 -467.5 -1472.5 { lab=B8}
N -350 -1422.5 -350 -1420 { lab=GND}
N -247.5 -1512.5 -232.5 -1512.5 { lab=Q8}
N -357.5 -1622.5 -357.5 -1607.5 { lab=VDD}
N -480 -1510 -467.5 -1510 { lab=clk}
N -352.5 -1397.5 -352.5 -1380 { lab=GND}
N -352.5 -1397.5 -350 -1397.5 { lab=GND}
N -350 -1002.5 -350 -997.5 { lab=GND}
N -350 -1020 -350 -1002.5 { lab=GND}
N -480 -1142.5 -467.5 -1142.5 { lab=A}
N -480 -1072.5 -467.5 -1072.5 { lab=B9}
N -350 -1022.5 -350 -1020 { lab=GND}
N -247.5 -1112.5 -232.5 -1112.5 { lab=Q9}
N -357.5 -1222.5 -357.5 -1207.5 { lab=VDD}
N -480 -1110 -467.5 -1110 { lab=clk}
N -352.5 -997.5 -352.5 -980 { lab=GND}
N -352.5 -997.5 -350 -997.5 { lab=GND}
N -350 -705 -350 -700 { lab=GND}
N -350 -722.5 -350 -705 { lab=GND}
N -480 -845 -467.5 -845 { lab=A}
N -480 -775 -467.5 -775 { lab=B10}
N -350 -725 -350 -722.5 { lab=GND}
N -247.5 -815 -232.5 -815 { lab=Q10}
N -357.5 -925 -357.5 -910 { lab=VDD}
N -480 -812.5 -467.5 -812.5 { lab=clk}
N -352.5 -700 -352.5 -682.5 { lab=GND}
N -352.5 -700 -350 -700 { lab=GND}
N -662.5 -3960 -662.5 -3950 { lab=GND}
N -662.5 -4040 -662.5 -4020 { lab=B10}
N -575 -3960 -575 -3950 { lab=GND}
N -575 -4040 -575 -4020 { lab=B9}
N -827.5 -3962.5 -827.5 -3952.5 { lab=GND}
N -827.5 -4042.5 -827.5 -4022.5 { lab=B12}
N -740 -3962.5 -740 -3952.5 { lab=GND}
N -740 -4042.5 -740 -4022.5 { lab=B11}
N -347.5 -355 -347.5 -350 { lab=GND}
N -347.5 -372.5 -347.5 -355 { lab=GND}
N -477.5 -495 -465 -495 { lab=A}
N -477.5 -425 -465 -425 { lab=B11}
N -347.5 -375 -347.5 -372.5 { lab=GND}
N -245 -465 -230 -465 { lab=Q11}
N -355 -575 -355 -560 { lab=VDD}
N -477.5 -462.5 -465 -462.5 { lab=clk}
N -350 -350 -350 -332.5 { lab=GND}
N -350 -350 -347.5 -350 { lab=GND}
N -347.5 -57.5 -347.5 -52.5 { lab=GND}
N -347.5 -75 -347.5 -57.5 { lab=GND}
N -477.5 -197.5 -465 -197.5 { lab=A}
N -477.5 -127.5 -465 -127.5 { lab=B12}
N -347.5 -77.5 -347.5 -75 { lab=GND}
N -245 -167.5 -230 -167.5 { lab=Q12}
N -355 -277.5 -355 -262.5 { lab=VDD}
N -477.5 -165 -465 -165 { lab=clk}
N -350 -52.5 -350 -35 { lab=GND}
N -350 -52.5 -347.5 -52.5 { lab=GND}
C {devices/vsource.sym} -490 -3990 0 0 {name=V3 value=1.35}
C {devices/vsource.sym} -962.5 -3835 0 0 {name=V4 value="pwl 0 0 12.5u 0 12.5u 0.6 22.5u 0.6 22.5u 0.7 32.5u 0.7 32.5u 0.8 42.5u 0.8 42.5u 0.9 52.5u 0.9 52.5u 1 62.5u 1 62.5u 1.1 72.5u 1.1 72.5u 1.2 82.5u 1.2 82.5u 1.3 92.5u 1.3 92.5u 1.4 102.5u 1.4 102.5u 1.5 112.5u 1.5 112.5u 1.6 122.5u 1.6 122.5u 1.7 132.5u 1.7 132.5u 1.8 142.5u 1.8 142.5u 1.9"}
C {devices/gnd.sym} -1182.5 -3795 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} -962.5 -3795 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -490 -3950 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -490 -4040 0 0 {name=l14 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -962.5 -3885 0 0 {name=l15 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -1182.5 -3885 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -1182.5 -3835 0 0 {name=V5 value="pulse 0 1.8 5n .1n .1n 1u 2u"}
C {devices/code.sym} -1012.5 -3695 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.1u 150u
plot A CLK+2 Q1+4 Q2+6 Q3+8 Q4+10 Q5+12 Q6+14 Q7+16 Q8+18 Q9+20 Q10+22 Q11+24 Q12+26
.endc
"}
C {devices/vsource.sym} -402.5 -3990 0 0 {name=V1 value=1.25}
C {devices/gnd.sym} -402.5 -3950 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -402.5 -4040 0 0 {name=l9 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} -322.5 -3990 0 0 {name=V2 value=1.15}
C {devices/gnd.sym} -322.5 -3950 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -322.5 -4040 0 0 {name=l17 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} -237.5 -3987.5 0 0 {name=V6 value=1.05}
C {devices/gnd.sym} -237.5 -3947.5 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -237.5 -4037.5 0 0 {name=l19 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} -160 -3985 0 0 {name=V7 value=0.95}
C {devices/gnd.sym} -160 -3945 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -160 -4035 0 0 {name=l46 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} -72.5 -3985 0 0 {name=V8 value=0.85}
C {devices/gnd.sym} -72.5 -3945 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -72.5 -4035 0 0 {name=l48 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 7.5 -3985 0 0 {name=V9 value=0.75}
C {devices/gnd.sym} 7.5 -3945 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 7.5 -4035 0 0 {name=l50 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 92.5 -3982.5 0 0 {name=V10 value=0.65}
C {devices/gnd.sym} 92.5 -3942.5 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} 92.5 -4032.5 0 0 {name=l52 sig_type=std_logic lab=B1
}
C {devices/code.sym} -1152.5 -3695 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice

"}
C {devices/vsource.sym} -1352.5 -3847.5 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} -1352.5 -3807.5 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1352.5 -3897.5 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} -505 -3692.5 0 0 {name=l1 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -505 -3622.5 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} -505 -3660 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -382.5 -3772.5 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -377.5 -3530 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -257.5 -3662.5 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {devices/lab_pin.sym} -502.5 -3402.5 0 0 {name=l7 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -502.5 -3332.5 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} -502.5 -3370 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -380 -3482.5 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -375 -3240 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -255 -3372.5 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} -495 -3110 0 0 {name=l25 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -495 -3040 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} -495 -3077.5 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -372.5 -3190 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -367.5 -2947.5 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -247.5 -3080 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {devices/lab_pin.sym} -497.5 -2792.5 0 0 {name=l31 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -497.5 -2722.5 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} -497.5 -2760 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -375 -2872.5 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -370 -2630 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -250 -2762.5 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {devices/lab_pin.sym} -497.5 -2477.5 0 0 {name=l37 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -497.5 -2407.5 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} -497.5 -2445 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -375 -2557.5 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -370 -2315 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -250 -2447.5 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {devices/lab_pin.sym} -490 -2157.5 0 0 {name=l43 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -490 -2087.5 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} -490 -2125 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -367.5 -2237.5 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -362.5 -1995 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -242.5 -2127.5 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {devices/lab_pin.sym} -480 -1840 0 0 {name=l59 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -480 -1770 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} -480 -1807.5 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -357.5 -1920 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -352.5 -1677.5 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} -232.5 -1810 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {devices/lab_pin.sym} -480 -1542.5 0 0 {name=l65 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -480 -1472.5 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -480 -1510 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -357.5 -1622.5 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -352.5 -1380 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -232.5 -1512.5 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} -480 -1142.5 0 0 {name=l71 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -480 -1072.5 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} -480 -1110 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -357.5 -1222.5 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -352.5 -980 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -232.5 -1112.5 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {devices/lab_pin.sym} -480 -845 0 0 {name=l77 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -480 -775 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} -480 -812.5 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -357.5 -925 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -352.5 -682.5 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -232.5 -815 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/vsource.sym} -662.5 -3990 0 0 {name=V12 value=1.55}
C {devices/gnd.sym} -662.5 -3950 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -662.5 -4040 0 0 {name=l84 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} -575 -3990 0 0 {name=V13 value=1.45}
C {devices/gnd.sym} -575 -3950 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -575 -4040 0 0 {name=l86 sig_type=std_logic lab=B9
}
C {cmpoaisch_2.sym} 125 -1470 0 0 {name=x2}
C {cmpoaisch_2.sym} 127.5 -1180 0 0 {name=x1}
C {cmpoaisch_2.sym} 135 -887.5 0 0 {name=x3}
C {cmpoaisch_2.sym} 132.5 -570 0 0 {name=x4}
C {cmpoaisch_2.sym} 132.5 -255 0 0 {name=x5}
C {cmpoaisch_2.sym} 140 65 0 0 {name=x6}
C {cmpoaisch_2.sym} 150 382.5 0 0 {name=x7}
C {cmpoaisch_2.sym} 150 680 0 0 {name=x8}
C {cmpoaisch_2.sym} 150 1080 0 0 {name=x9}
C {cmpoaisch_2.sym} 150 1377.5 0 0 {name=x10}
C {devices/vsource.sym} -827.5 -3992.5 0 0 {name=V14 value=1.75}
C {devices/gnd.sym} -827.5 -3952.5 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -827.5 -4042.5 0 0 {name=l88 sig_type=std_logic lab=B12
}
C {devices/vsource.sym} -740 -3992.5 0 0 {name=V15 value=1.65}
C {devices/gnd.sym} -740 -3952.5 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -740 -4042.5 0 0 {name=l90 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} -477.5 -495 0 0 {name=l91 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -477.5 -425 0 0 {name=l92 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} -477.5 -462.5 0 0 {name=l93 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -355 -575 0 0 {name=l94 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -350 -332.5 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -230 -465 2 0 {name=l96 sig_type=std_logic lab=Q11
}
C {devices/lab_pin.sym} -477.5 -197.5 0 0 {name=l97 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -477.5 -127.5 0 0 {name=l98 sig_type=std_logic lab=B12}
C {devices/lab_pin.sym} -477.5 -165 0 0 {name=l99 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -355 -277.5 0 0 {name=l100 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -350 -35 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -230 -167.5 2 0 {name=l102 sig_type=std_logic lab=Q12}
C {cmpoaisch_2.sym} 152.5 1727.5 0 0 {name=x11}
C {cmpoaisch_2.sym} 152.5 2025 0 0 {name=x12}
