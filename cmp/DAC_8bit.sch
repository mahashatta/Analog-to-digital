v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -342652.5 -2384510 -342640 -2384510 { lab=In1}
N -342652.5 -2384435 -342640 -2384435 { lab=D1}
N -342652.5 -2384422.5 -342640 -2384422.5 { lab=D0}
N -342927.5 -2384482.5 -342927.5 -2384470 { lab=In1}
N -342927.5 -2384410 -342927.5 -2384390 { lab=vref1}
N -342927.5 -2384390 -342927.5 -2384387.5 { lab=vref1}
N -342927.5 -2384327.5 -342927.5 -2384310 { lab=vref1}
N -342927.5 -2384310 -342927.5 -2384300 { lab=vref1}
N -342927.5 -2384240 -342927.5 -2384222.5 { lab=In2}
N -342652.5 -2384410 -342640 -2384410 { lab=vref1}
N -342515 -2384577.5 -342515 -2384565 { lab=Vdd}
N -342387.5 -2384460 -342337.5 -2384460 { lab=#net1}
N -342335 -2384387.5 -342270 -2384387.5 { lab=#net1}
N -342335 -2384460 -342335 -2384387.5 { lab=#net1}
N -342337.5 -2384460 -342335 -2384460 { lab=#net1}
N -342335 -2384292.5 -342270 -2384292.5 { lab=#net2}
N -342335 -2384292.5 -342335 -2384215 { lab=#net2}
N -342342.5 -2384215 -342335 -2384215 { lab=#net2}
N -342145 -2384470 -342145 -2384460 { lab=Vdd}
N -342032.5 -2384345 -342020 -2384345 { lab=out}
N -342135 -2384247.5 -342135 -2384235 { lab=D7}
N -342927.5 -2384387.5 -342927.5 -2384330 { lab=vref1}
N -342927.5 -2384330 -342927.5 -2384327.5 { lab=vref1}
N -342652.5 -2384447.5 -342640 -2384447.5 { lab=D2}
N -342652.5 -2384472.5 -342640 -2384472.5 { lab=D4}
N -342387.5 -2384215 -342342.5 -2384215 { lab=#net2}
N -342652.5 -2384460 -342640 -2384460 { lab=D3}
N -342652.5 -2384485 -342640 -2384485 { lab=D5}
N -342652.5 -2384497.5 -342640 -2384497.5 { lab=D6}
N -342652.5 -2384265 -342640 -2384265 { lab=vref1}
N -342652.5 -2384190 -342640 -2384190 { lab=D1}
N -342652.5 -2384177.5 -342640 -2384177.5 { lab=D0}
N -342652.5 -2384165 -342640 -2384165 { lab=In2}
N -342515 -2384332.5 -342515 -2384320 { lab=Vdd}
N -342652.5 -2384202.5 -342640 -2384202.5 { lab=D2}
N -342652.5 -2384227.5 -342640 -2384227.5 { lab=D4}
N -342652.5 -2384215 -342640 -2384215 { lab=D3}
N -342652.5 -2384240 -342640 -2384240 { lab=D5}
N -342652.5 -2384252.5 -342640 -2384252.5 { lab=D6}
C {devices/res.sym} -342927.5 -2384440 0 0 {name=R8
value=250
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} -342652.5 -2384510 0 0 {name=l12 sig_type=std_logic lab=In1}
C {devices/lab_pin.sym} -342515 -2384577.5 2 0 {name=l14 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -342145 -2384470 2 0 {name=l15 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -342652.5 -2384422.5 0 0 {name=l23 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -342652.5 -2384435 0 0 {name=l24 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -342020 -2384345 2 0 {name=l25 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} -342927.5 -2384482.5 0 0 {name=l7 sig_type=std_logic lab=In1}
C {devices/res.sym} -342927.5 -2384270 0 0 {name=R6
value=250
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} -342927.5 -2384222.5 0 0 {name=l9 sig_type=std_logic lab=In2}
C {devices/lab_pin.sym} -342927.5 -2384397.5 0 0 {name=l10 sig_type=std_logic lab=vref1}
C {devices/lab_pin.sym} -342652.5 -2384410 0 0 {name=l11 sig_type=std_logic lab=vref1}
C {TG.sym} -342265 -2382900 0 0 {name=x3}
C {devices/lab_pin.sym} -342135 -2384235 0 0 {name=l1 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} -342652.5 -2384447.5 0 0 {name=l2 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -342652.5 -2384472.5 0 0 {name=l8 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -342652.5 -2384460 0 0 {name=l17 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -342652.5 -2384165 0 0 {name=l13 sig_type=std_logic lab=In2}
C {devices/lab_pin.sym} -342652.5 -2384485 0 0 {name=l3 sig_type=std_logic lab=D5}
C {DAC_7bit.sym} -203700 -1386502.5 0 0 {name=x1}
C {devices/lab_pin.sym} -342652.5 -2384497.5 0 0 {name=l4 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -342652.5 -2384265 0 0 {name=l5 sig_type=std_logic lab=vref1}
C {devices/lab_pin.sym} -342515 -2384332.5 2 0 {name=l6 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -342652.5 -2384177.5 0 0 {name=l16 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -342652.5 -2384190 0 0 {name=l18 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -342652.5 -2384202.5 0 0 {name=l20 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -342652.5 -2384227.5 0 0 {name=l21 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -342652.5 -2384215 0 0 {name=l22 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -342652.5 -2384240 0 0 {name=l26 sig_type=std_logic lab=D5}
C {DAC_7bit.sym} -203700 -1386257.5 0 0 {name=x2}
C {devices/lab_pin.sym} -342652.5 -2384252.5 0 0 {name=l27 sig_type=std_logic lab=D6}
