v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -140 -1575 -140 -1570 { lab=GND}
N -140 -1592.5 -140 -1575 { lab=GND}
N -270 -1715 -257.5 -1715 { lab=A}
N -270 -1645 -257.5 -1645 { lab=B1}
N -140 -1595 -140 -1592.5 { lab=GND}
N -37.5 -1685 -22.5 -1685 { lab=Q1}
N -255 -1982.5 -255 -1972.5 { lab=GND}
N -727.5 -1827.5 -727.5 -1817.5 { lab=GND}
N -947.5 -1827.5 -947.5 -1817.5 { lab=GND}
N -947.5 -1907.5 -947.5 -1887.5 { lab=clk}
N -727.5 -1907.5 -727.5 -1887.5 { lab=A}
N -255 -2062.5 -255 -2042.5 { lab=B8}
N -167.5 -1982.5 -167.5 -1972.5 { lab=GND}
N -167.5 -2062.5 -167.5 -2042.5 { lab=B7}
N -87.5 -1982.5 -87.5 -1972.5 { lab=GND}
N -87.5 -2062.5 -87.5 -2042.5 { lab=B6}
N -2.5 -1980 -2.5 -1970 { lab=GND}
N -2.5 -2060 -2.5 -2040 { lab=B5}
N 75 -1977.5 75 -1967.5 { lab=GND}
N 75 -2057.5 75 -2037.5 { lab=B4}
N 162.5 -1977.5 162.5 -1967.5 { lab=GND}
N 162.5 -2057.5 162.5 -2037.5 { lab=B3}
N 242.5 -1977.5 242.5 -1967.5 { lab=GND}
N 242.5 -2057.5 242.5 -2037.5 { lab=B2}
N 327.5 -1975 327.5 -1965 { lab=GND}
N 327.5 -2055 327.5 -2035 { lab=B1}
N -1117.5 -1840 -1117.5 -1830 { lab=GND}
N -1117.5 -1920 -1117.5 -1900 { lab=VDD}
N -147.5 -1795 -147.5 -1780 { lab=VDD}
N -270 -1682.5 -257.5 -1682.5 { lab=clk}
N -142.5 -1570 -142.5 -1552.5 { lab=GND}
N -142.5 -1570 -140 -1570 { lab=GND}
N -137.5 -1285 -137.5 -1280 { lab=GND}
N -137.5 -1302.5 -137.5 -1285 { lab=GND}
N -267.5 -1425 -255 -1425 { lab=A}
N -267.5 -1355 -255 -1355 { lab=B2}
N -137.5 -1305 -137.5 -1302.5 { lab=GND}
N -35 -1395 -20 -1395 { lab=Q2}
N -145 -1505 -145 -1490 { lab=VDD}
N -267.5 -1392.5 -255 -1392.5 { lab=clk}
N -140 -1280 -140 -1262.5 { lab=GND}
N -140 -1280 -137.5 -1280 { lab=GND}
N -130 -992.5 -130 -987.5 { lab=GND}
N -130 -1010 -130 -992.5 { lab=GND}
N -260 -1132.5 -247.5 -1132.5 { lab=A}
N -260 -1062.5 -247.5 -1062.5 { lab=B3}
N -130 -1012.5 -130 -1010 { lab=GND}
N -27.5 -1102.5 -12.5 -1102.5 { lab=Q3}
N -137.5 -1212.5 -137.5 -1197.5 { lab=VDD}
N -260 -1100 -247.5 -1100 { lab=clk}
N -132.5 -987.5 -132.5 -970 { lab=GND}
N -132.5 -987.5 -130 -987.5 { lab=GND}
N -132.5 -675 -132.5 -670 { lab=GND}
N -132.5 -692.5 -132.5 -675 { lab=GND}
N -262.5 -815 -250 -815 { lab=A}
N -262.5 -745 -250 -745 { lab=B4}
N -132.5 -695 -132.5 -692.5 { lab=GND}
N -30 -785 -15 -785 { lab=Q4}
N -140 -895 -140 -880 { lab=VDD}
N -262.5 -782.5 -250 -782.5 { lab=clk}
N -135 -670 -135 -652.5 { lab=GND}
N -135 -670 -132.5 -670 { lab=GND}
N -132.5 -360 -132.5 -355 { lab=GND}
N -132.5 -377.5 -132.5 -360 { lab=GND}
N -262.5 -500 -250 -500 { lab=A}
N -262.5 -430 -250 -430 { lab=B5}
N -132.5 -380 -132.5 -377.5 { lab=GND}
N -30 -470 -15 -470 { lab=Q5}
N -140 -580 -140 -565 { lab=VDD}
N -262.5 -467.5 -250 -467.5 { lab=clk}
N -135 -355 -135 -337.5 { lab=GND}
N -135 -355 -132.5 -355 { lab=GND}
N -125 -40 -125 -35 { lab=GND}
N -125 -57.5 -125 -40 { lab=GND}
N -255 -180 -242.5 -180 { lab=A}
N -255 -110 -242.5 -110 { lab=B6}
N -125 -60 -125 -57.5 { lab=GND}
N -22.5 -150 -7.5 -150 { lab=Q6}
N -132.5 -260 -132.5 -245 { lab=VDD}
N -255 -147.5 -242.5 -147.5 { lab=clk}
N -127.5 -35 -127.5 -17.5 { lab=GND}
N -127.5 -35 -125 -35 { lab=GND}
N -115 277.5 -115 282.5 { lab=GND}
N -115 260 -115 277.5 { lab=GND}
N -245 137.5 -232.5 137.5 { lab=A}
N -245 207.5 -232.5 207.5 { lab=B7}
N -115 257.5 -115 260 { lab=GND}
N -12.5 167.5 2.5 167.5 { lab=Q7}
N -122.5 57.5 -122.5 72.5 { lab=VDD}
N -245 170 -232.5 170 { lab=clk}
N -117.5 282.5 -117.5 300 { lab=GND}
N -117.5 282.5 -115 282.5 { lab=GND}
N -115 575 -115 580 { lab=GND}
N -115 557.5 -115 575 { lab=GND}
N -245 435 -232.5 435 { lab=A}
N -245 505 -232.5 505 { lab=B8}
N -115 555 -115 557.5 { lab=GND}
N -12.5 465 2.5 465 { lab=Q8}
N -122.5 355 -122.5 370 { lab=VDD}
N -245 467.5 -232.5 467.5 { lab=clk}
N -117.5 580 -117.5 597.5 { lab=GND}
N -117.5 580 -115 580 { lab=GND}
N -115 975 -115 980 { lab=GND}
N -115 957.5 -115 975 { lab=GND}
N -245 835 -232.5 835 { lab=A}
N -245 905 -232.5 905 { lab=B9}
N -115 955 -115 957.5 { lab=GND}
N -12.5 865 2.5 865 { lab=Q9}
N -122.5 755 -122.5 770 { lab=VDD}
N -245 867.5 -232.5 867.5 { lab=clk}
N -117.5 980 -117.5 997.5 { lab=GND}
N -117.5 980 -115 980 { lab=GND}
N -115 1272.5 -115 1277.5 { lab=GND}
N -115 1255 -115 1272.5 { lab=GND}
N -245 1132.5 -232.5 1132.5 { lab=A}
N -245 1202.5 -232.5 1202.5 { lab=B10}
N -115 1252.5 -115 1255 { lab=GND}
N -12.5 1162.5 2.5 1162.5 { lab=Q10}
N -122.5 1052.5 -122.5 1067.5 { lab=VDD}
N -245 1165 -232.5 1165 { lab=clk}
N -117.5 1277.5 -117.5 1295 { lab=GND}
N -117.5 1277.5 -115 1277.5 { lab=GND}
N -427.5 -1982.5 -427.5 -1972.5 { lab=GND}
N -427.5 -2062.5 -427.5 -2042.5 { lab=B10}
N -340 -1982.5 -340 -1972.5 { lab=GND}
N -340 -2062.5 -340 -2042.5 { lab=B9}
C {devices/vsource.sym} -255 -2012.5 0 0 {name=V3 value=0.75}
C {devices/vsource.sym} -727.5 -1857.5 0 0 {name=V4 value="pwl 0 0 12.5u 0 12.5u 0.1 12.5u 0.2 22.5u 0.2 22.5u 0.3 32.5u 0.3 32.5u 0.4 42.5u 0.4 42.5u 0.5 52.5u 0.5 52.5u 0.6 62.5u 0.6 62.5u 0.7 72.5u 0.7 72.5u 0.8 82.5u 0.8 82.5u 0.9 92.5u 0.9 92.5u 1 102.5u 1 102.5 1.2 112.5u 1.2 122.5u 1.35"}
C {devices/gnd.sym} -947.5 -1817.5 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} -727.5 -1817.5 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -255 -1972.5 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -255 -2062.5 0 0 {name=l14 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -727.5 -1907.5 0 0 {name=l15 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -947.5 -1907.5 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -947.5 -1857.5 0 0 {name=V5 value="pulse 0 1.8 5n .1n .1n 1u 2u"}
C {devices/code.sym} -777.5 -1717.5 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.1u 115u
plot A CLK+2 Q1+4 Q2+6 Q3+8 Q4+10 Q5+12 Q6+14 Q7+16 Q8+18 Q9+20 Q10+22
.endc
"}
C {devices/vsource.sym} -167.5 -2012.5 0 0 {name=V1 value=0.65}
C {devices/gnd.sym} -167.5 -1972.5 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -167.5 -2062.5 0 0 {name=l9 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} -87.5 -2012.5 0 0 {name=V2 value=0.55}
C {devices/gnd.sym} -87.5 -1972.5 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -87.5 -2062.5 0 0 {name=l17 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} -2.5 -2010 0 0 {name=V6 value=0.45}
C {devices/gnd.sym} -2.5 -1970 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2.5 -2060 0 0 {name=l19 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} 75 -2007.5 0 0 {name=V7 value=0.35}
C {devices/gnd.sym} 75 -1967.5 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} 75 -2057.5 0 0 {name=l46 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} 162.5 -2007.5 0 0 {name=V8 value=0.25}
C {devices/gnd.sym} 162.5 -1967.5 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} 162.5 -2057.5 0 0 {name=l48 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 242.5 -2007.5 0 0 {name=V9 value=0.15}
C {devices/gnd.sym} 242.5 -1967.5 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 242.5 -2057.5 0 0 {name=l50 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 327.5 -2005 0 0 {name=V10 value=0.05}
C {devices/gnd.sym} 327.5 -1965 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} 327.5 -2055 0 0 {name=l52 sig_type=std_logic lab=B1
}
C {devices/code.sym} -917.5 -1717.5 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice

"}
C {devices/vsource.sym} -1117.5 -1870 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} -1117.5 -1830 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1117.5 -1920 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {cmpoaisch.sym} 162.5 -760 0 0 {name=x1}
C {devices/lab_pin.sym} -270 -1715 0 0 {name=l1 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -270 -1645 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} -270 -1682.5 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -147.5 -1795 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -142.5 -1552.5 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -22.5 -1685 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {cmpoaisch.sym} 165 -470 0 0 {name=x2}
C {devices/lab_pin.sym} -267.5 -1425 0 0 {name=l7 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -267.5 -1355 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} -267.5 -1392.5 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -145 -1505 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -140 -1262.5 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -20 -1395 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {cmpoaisch.sym} 172.5 -177.5 0 0 {name=x3}
C {devices/lab_pin.sym} -260 -1132.5 0 0 {name=l25 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -260 -1062.5 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} -260 -1100 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -137.5 -1212.5 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -132.5 -970 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -12.5 -1102.5 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {cmpoaisch.sym} 170 140 0 0 {name=x4}
C {devices/lab_pin.sym} -262.5 -815 0 0 {name=l31 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -262.5 -745 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} -262.5 -782.5 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -140 -895 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -135 -652.5 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -15 -785 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {cmpoaisch.sym} 170 455 0 0 {name=x5}
C {devices/lab_pin.sym} -262.5 -500 0 0 {name=l37 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -262.5 -430 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} -262.5 -467.5 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -140 -580 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -135 -337.5 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -15 -470 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {cmpoaisch.sym} 177.5 775 0 0 {name=x6}
C {devices/lab_pin.sym} -255 -180 0 0 {name=l43 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -255 -110 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} -255 -147.5 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -132.5 -260 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -127.5 -17.5 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -7.5 -150 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {cmpoaisch.sym} 187.5 1092.5 0 0 {name=x7}
C {devices/lab_pin.sym} -245 137.5 0 0 {name=l59 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 207.5 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} -245 170 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 57.5 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 300 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 2.5 167.5 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {cmpoaisch.sym} 187.5 1390 0 0 {name=x8}
C {devices/lab_pin.sym} -245 435 0 0 {name=l65 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 505 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -245 467.5 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 355 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 597.5 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 2.5 465 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {cmpoaisch.sym} 187.5 1790 0 0 {name=x9}
C {devices/lab_pin.sym} -245 835 0 0 {name=l71 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 905 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} -245 867.5 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 755 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 997.5 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 2.5 865 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {cmpoaisch.sym} 187.5 2087.5 0 0 {name=x10}
C {devices/lab_pin.sym} -245 1132.5 0 0 {name=l77 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 1202.5 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} -245 1165 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 1052.5 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 1295 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 2.5 1162.5 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/vsource.sym} -427.5 -2012.5 0 0 {name=V12 value=1.35}
C {devices/gnd.sym} -427.5 -1972.5 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -427.5 -2062.5 0 0 {name=l84 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} -340 -2012.5 0 0 {name=V13 value=1.15}
C {devices/gnd.sym} -340 -1972.5 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -340 -2062.5 0 0 {name=l86 sig_type=std_logic lab=B9
}
