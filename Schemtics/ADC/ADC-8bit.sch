v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -23860162.5 -159907245 -23860162.5 -159907235 { lab=GND}
N -23860162.5 -159907325 -23860162.5 -159907305 { lab=Vdd}
N -23860165 -159907117.5 -23860165 -159907107.5 { lab=GND}
N -23860165 -159907197.5 -23860165 -159907177.5 { lab=In1}
N -23860167.5 -159906995 -23860167.5 -159906985 { lab=GND}
N -23860167.5 -159907075 -23860167.5 -159907055 { lab=In2}
N -23860042.5 -159907245 -23860042.5 -159907235 { lab=GND}
N -23860042.5 -159907325 -23860042.5 -159907305 { lab=Vin}
N -23858982.5 -159907297.5 -23858982.5 -159907290 { lab=Vdd}
N -23858975 -159907105 -23858975 -159907095 { lab=GND}
N -23859165 -159907335 -23859142.5 -159907335 { lab=dac}
N -23859142.5 -159907335 -23859142.5 -159907155 { lab=dac}
N -23859142.5 -159907155 -23859092.5 -159907155 { lab=dac}
N -23859110 -159907225 -23859092.5 -159907225 { lab=Vin}
N -23858872.5 -159907195 -23858860 -159907195 { lab=cmp}
N -23860042.5 -159907115 -23860042.5 -159907105 { lab=GND}
N -23860042.5 -159907195 -23860042.5 -159907175 { lab=clk}
N -23859110 -159907192.5 -23859092.5 -159907192.5 { lab=clkn}
N -23860162.5 -159906860 -23860162.5 -159906850 { lab=GND}
N -23860162.5 -159906940 -23860162.5 -159906920 { lab=VPB}
N -23860165 -159906732.5 -23860165 -159906722.5 { lab=GND}
N -23860165 -159906812.5 -23860165 -159906792.5 { lab=VPWR}
N -23860045 -159906860 -23860045 -159906850 { lab=GND}
N -23860045 -159906940 -23860045 -159906920 { lab=VNB}
N -23860047.5 -159906732.5 -23860047.5 -159906722.5 { lab=GND}
N -23860047.5 -159906812.5 -23860047.5 -159906792.5 { lab=VGND}
N -23859750 -159907492.5 -23859750 -159907485 { lab=VPWR}
N -23859730 -159907492.5 -23859730 -159907485 { lab=VGND}
N -23859710 -159907492.5 -23859710 -159907485 { lab=VPB}
N -23859690 -159907492.5 -23859690 -159907485 { lab=VNB}
N -23860042.5 -159906992.5 -23860042.5 -159906982.5 { lab=GND}
N -23860042.5 -159907072.5 -23860042.5 -159907052.5 { lab=start}
N -23859855 -159907407.5 -23859842.5 -159907407.5 { lab=start}
N -23859855 -159907390 -23859842.5 -159907390 { lab=clk}
N -23859855 -159907370 -23859842.5 -159907370 { lab=rstn}
N -23859855 -159907352.5 -23859842.5 -159907352.5 { lab=cmp}
N -23860042.5 -159906600 -23860042.5 -159906590 { lab=GND}
N -23860042.5 -159906680 -23860042.5 -159906660 { lab=rstn}
N -23859422.5 -159907395 -23859417.5 -159907395 { lab=In1}
N -23859587.5 -159907467.5 -23859582.5 -159907467.5 { lab=clkn}
N -23859587.5 -159907457.5 -23859582.5 -159907457.5 { lab=done}
N -23859590 -159907437.5 -23859585 -159907437.5 { lab=out.6}
N -23859590 -159907427.5 -23859585 -159907427.5 { lab=out.5}
N -23859590 -159907417.5 -23859585 -159907417.5 { lab=out.4}
N -23859590 -159907407.5 -23859585 -159907407.5 { lab=out.3}
N -23859590 -159907397.5 -23859585 -159907397.5 { lab=out.2}
N -23859590 -159907387.5 -23859585 -159907387.5 { lab=out.1}
N -23859590 -159907377.5 -23859585 -159907377.5 { lab=out.0}
N -23859292.5 -159907452.5 -23859292.5 -159907440 { lab=Vdd}
N -23859590 -159907447.5 -23859585 -159907447.5 { lab=out.7}
N -23859590 -159907297.5 -23859417.5 -159907297.5 { lab=#net1}
N -23859590 -159907307.5 -23859425 -159907307.5 { lab=#net2}
N -23859425 -159907310 -23859425 -159907307.5 { lab=#net2}
N -23859425 -159907310 -23859417.5 -159907310 { lab=#net2}
N -23859590 -159907317.5 -23859427.5 -159907317.5 { lab=#net3}
N -23859427.5 -159907322.5 -23859427.5 -159907317.5 { lab=#net3}
N -23859427.5 -159907322.5 -23859417.5 -159907322.5 { lab=#net3}
N -23859590 -159907327.5 -23859427.5 -159907327.5 { lab=#net4}
N -23859427.5 -159907335 -23859427.5 -159907327.5 { lab=#net4}
N -23859427.5 -159907335 -23859417.5 -159907335 { lab=#net4}
N -23859590 -159907337.5 -23859430 -159907337.5 { lab=#net5}
N -23859430 -159907347.5 -23859430 -159907337.5 { lab=#net5}
N -23859430 -159907347.5 -23859417.5 -159907347.5 { lab=#net5}
N -23859590 -159907347.5 -23859435 -159907347.5 { lab=#net6}
N -23859435 -159907360 -23859435 -159907347.5 { lab=#net6}
N -23859435 -159907360 -23859417.5 -159907360 { lab=#net6}
N -23859590 -159907357.5 -23859442.5 -159907357.5 { lab=#net7}
N -23859442.5 -159907372.5 -23859442.5 -159907357.5 { lab=#net7}
N -23859442.5 -159907372.5 -23859417.5 -159907372.5 { lab=#net7}
N -23859590 -159907367.5 -23859450 -159907367.5 { lab=#net8}
N -23859450 -159907385 -23859450 -159907367.5 { lab=#net8}
N -23859450 -159907385 -23859417.5 -159907385 { lab=#net8}
N -23859427.5 -159907285 -23859417.5 -159907285 { lab=In2}
N -23859427.5 -159907285 -23859427.5 -159907272.5 { lab=In2}
N -23859590 -159907467.5 -23859587.5 -159907467.5 { lab=clkn}
N -23859590 -159907457.5 -23859587.5 -159907457.5 { lab=done}
C {cmpoai_all.sym} -23857932.5 -159904427.5 0 0 {name=x2}
C {devices/vsource.sym} -23860162.5 -159907275 0 0 {name=V8 value=1.8}
C {devices/gnd.sym} -23860162.5 -159907235 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -23860162.5 -159907325 0 0 {name=l27 sig_type=std_logic lab=Vdd
}
C {devices/code.sym} -23860090 -159907480 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.5u 50u
plot dac vin out.7+2 out.6+4 out.5+6 out.4+8 out.3+10 out.2+12 out.1+14 out.0+16 done+18 clk+20 clkn+22 rstn+24 cmp+28 
meas tran x find v(dac) when v(done)=1.8
.endc
"}
C {devices/code.sym} -23860230 -159907480 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/corners/tt/nonfet.spice
* Mismatch parameters
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/Capacitor
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/r+c/res_typical__cap_typical.spice
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/corners/tt/specialized_cells.spice
* All models
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/all.spice
* Corner
.include ~/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand4/sky130_fd_sc_hd__nand4_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2b/sky130_fd_sc_hd__nand2b_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3b/sky130_fd_sc_hd__nand3b_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/buf/sky130_fd_sc_hd__buf_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfstp/sky130_fd_sc_hd__dfstp_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfxtp/sky130_fd_sc_hd__dfxtp_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2b/sky130_fd_sc_hd__nor2b_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice


"}
C {devices/vsource.sym} -23860165 -159907147.5 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -23860165 -159907107.5 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -23860165 -159907197.5 0 0 {name=l5 sig_type=std_logic lab=In1
}
C {devices/vsource.sym} -23860167.5 -159907025 0 0 {name=V2 value=0}
C {devices/gnd.sym} -23860167.5 -159906985 0 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -23860167.5 -159907075 0 0 {name=l18 sig_type=std_logic lab=In2
}
C {devices/vsource.sym} -23860042.5 -159907275 0 0 {name=V3 value=0.225}
C {devices/gnd.sym} -23860042.5 -159907235 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -23860042.5 -159907325 0 0 {name=l3 sig_type=std_logic lab=Vin
}
C {devices/lab_pin.sym} -23858982.5 -159907297.5 0 0 {name=l4 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -23858975 -159907095 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} -23859422.5 -159907395 1 0 {name=l7 sig_type=std_logic lab=In1
}
C {devices/lab_pin.sym} -23859427.5 -159907272.5 3 0 {name=l8 sig_type=std_logic lab=In2
}
C {devices/lab_pin.sym} -23859292.5 -159907452.5 0 0 {name=l9 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -23859110 -159907225 0 0 {name=l10 sig_type=std_logic lab=Vin
}
C {devices/lab_pin.sym} -23858860 -159907195 2 0 {name=l11 sig_type=std_logic lab=cmp
}
C {devices/gnd.sym} -23860042.5 -159907105 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -23860042.5 -159907195 0 0 {name=l22 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -23860042.5 -159907145 0 0 {name=V5 value="pulse 0 1.8 2u .1n .1n 2u 4u"}
C {devices/lab_pin.sym} -23859110 -159907192.5 0 0 {name=l23 sig_type=std_logic lab=clkn
}
C {devices/lab_pin.sym} -23859142.5 -159907330 2 0 {name=l24 sig_type=std_logic lab=dac
}
C {DAC_8bit.sym} -23377487.5 -156525010 0 0 {name=x1}
C {devices/vsource.sym} -23860162.5 -159906890 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -23860162.5 -159906850 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -23860162.5 -159906940 0 0 {name=l16 sig_type=std_logic lab=VPB
}
C {devices/vsource.sym} -23860165 -159906762.5 0 0 {name=V7 value=1.8}
C {devices/gnd.sym} -23860165 -159906722.5 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -23860165 -159906812.5 0 0 {name=l20 sig_type=std_logic lab=VPWR
}
C {devices/vsource.sym} -23860045 -159906890 0 0 {name=V9 value=0}
C {devices/gnd.sym} -23860045 -159906850 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -23860045 -159906940 0 0 {name=l26 sig_type=std_logic lab=VNB
}
C {devices/vsource.sym} -23860047.5 -159906762.5 0 0 {name=V10 value=0}
C {devices/gnd.sym} -23860047.5 -159906722.5 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -23860047.5 -159906812.5 0 0 {name=l29 sig_type=std_logic lab=VGND
}
C {devices/lab_pin.sym} -23859750 -159907492.5 1 0 {name=l30 sig_type=std_logic lab=VPWR
}
C {devices/lab_pin.sym} -23859730 -159907492.5 1 0 {name=l31 sig_type=std_logic lab=VGND
}
C {devices/lab_pin.sym} -23859710 -159907492.5 1 0 {name=l32 sig_type=std_logic lab=VPB
}
C {devices/lab_pin.sym} -23859690 -159907492.5 1 0 {name=l33 sig_type=std_logic lab=VNB
}
C {devices/gnd.sym} -23860042.5 -159906982.5 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -23860042.5 -159907072.5 0 0 {name=l14 sig_type=std_logic lab=start}
C {devices/vsource.sym} -23860042.5 -159907022.5 0 0 {name=V4 value=1.8}
C {devices/lab_pin.sym} -23859855 -159907407.5 0 0 {name=l34 sig_type=std_logic lab=start}
C {devices/lab_pin.sym} -23859855 -159907390 0 0 {name=l35 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -23859855 -159907370 0 0 {name=l36 sig_type=std_logic lab=rstn}
C {devices/lab_pin.sym} -23859855 -159907352.5 0 0 {name=l37 sig_type=std_logic lab=cmp}
C {devices/gnd.sym} -23860042.5 -159906590 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -23860042.5 -159906680 0 0 {name=l39 sig_type=std_logic lab=rstn}
C {devices/vsource.sym} -23860042.5 -159906630 0 0 {name=V11 value="pulse 0 1.8 8u .1n .1n 40u 80u"}
C {devices/lab_pin.sym} -23859582.5 -159907467.5 2 0 {name=l40 sig_type=std_logic lab=clkn
}
C {devices/lab_pin.sym} -23859582.5 -159907457.5 2 0 {name=l41 sig_type=std_logic lab=done
}
C {SAR-8bit.sym} -13495607.5 -103292025 0 0 {name=x3}
C {devices/lab_pin.sym} -23859585 -159907447.5 2 0 {name=l42 sig_type=std_logic lab=out.7
}
C {devices/lab_pin.sym} -23859585 -159907437.5 2 0 {name=l43 sig_type=std_logic lab=out.6
}
C {devices/lab_pin.sym} -23859585 -159907427.5 2 0 {name=l44 sig_type=std_logic lab=out.5
}
C {devices/lab_pin.sym} -23859585 -159907417.5 2 0 {name=l45 sig_type=std_logic lab=out.4
}
C {devices/lab_pin.sym} -23859585 -159907407.5 2 0 {name=l46 sig_type=std_logic lab=out.3
}
C {devices/lab_pin.sym} -23859585 -159907397.5 2 0 {name=l47 sig_type=std_logic lab=out.2
}
C {devices/lab_pin.sym} -23859585 -159907387.5 2 0 {name=l48 sig_type=std_logic lab=out.1
}
C {devices/lab_pin.sym} -23859585 -159907377.5 2 0 {name=l49 sig_type=std_logic lab=out.0
}
