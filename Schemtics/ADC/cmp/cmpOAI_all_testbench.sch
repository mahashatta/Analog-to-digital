v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -312.5 -4492.5 -312.5 -4487.5 { lab=GND}
N -312.5 -4510 -312.5 -4492.5 { lab=GND}
N -442.5 -4632.5 -430 -4632.5 { lab=A}
N -442.5 -4562.5 -430 -4562.5 { lab=B1}
N -312.5 -4512.5 -312.5 -4510 { lab=GND}
N -210 -4602.5 -195 -4602.5 { lab=Q1}
N -1120 -4745 -1120 -4735 { lab=GND}
N -1120 -4825 -1120 -4805 { lab=clk}
N -1290 -4757.5 -1290 -4747.5 { lab=GND}
N -1290 -4837.5 -1290 -4817.5 { lab=VDD}
N -320 -4712.5 -320 -4697.5 { lab=VDD}
N -442.5 -4600 -430 -4600 { lab=clk}
N -315 -4487.5 -315 -4470 { lab=GND}
N -315 -4487.5 -312.5 -4487.5 { lab=GND}
N -310 -4202.5 -310 -4197.5 { lab=GND}
N -310 -4220 -310 -4202.5 { lab=GND}
N -440 -4342.5 -427.5 -4342.5 { lab=A}
N -440 -4272.5 -427.5 -4272.5 { lab=B2}
N -310 -4222.5 -310 -4220 { lab=GND}
N -207.5 -4312.5 -192.5 -4312.5 { lab=Q2}
N -317.5 -4422.5 -317.5 -4407.5 { lab=VDD}
N -440 -4310 -427.5 -4310 { lab=clk}
N -312.5 -4197.5 -312.5 -4180 { lab=GND}
N -312.5 -4197.5 -310 -4197.5 { lab=GND}
N -302.5 -3910 -302.5 -3905 { lab=GND}
N -302.5 -3927.5 -302.5 -3910 { lab=GND}
N -432.5 -4050 -420 -4050 { lab=A}
N -432.5 -3980 -420 -3980 { lab=B3}
N -302.5 -3930 -302.5 -3927.5 { lab=GND}
N -200 -4020 -185 -4020 { lab=Q3}
N -310 -4130 -310 -4115 { lab=VDD}
N -432.5 -4017.5 -420 -4017.5 { lab=clk}
N -305 -3905 -305 -3887.5 { lab=GND}
N -305 -3905 -302.5 -3905 { lab=GND}
N -305 -3592.5 -305 -3587.5 { lab=GND}
N -305 -3610 -305 -3592.5 { lab=GND}
N -435 -3732.5 -422.5 -3732.5 { lab=A}
N -435 -3662.5 -422.5 -3662.5 { lab=B4}
N -305 -3612.5 -305 -3610 { lab=GND}
N -202.5 -3702.5 -187.5 -3702.5 { lab=Q4}
N -312.5 -3812.5 -312.5 -3797.5 { lab=VDD}
N -435 -3700 -422.5 -3700 { lab=clk}
N -307.5 -3587.5 -307.5 -3570 { lab=GND}
N -307.5 -3587.5 -305 -3587.5 { lab=GND}
N -305 -3277.5 -305 -3272.5 { lab=GND}
N -305 -3295 -305 -3277.5 { lab=GND}
N -435 -3417.5 -422.5 -3417.5 { lab=A}
N -435 -3347.5 -422.5 -3347.5 { lab=B5}
N -305 -3297.5 -305 -3295 { lab=GND}
N -202.5 -3387.5 -187.5 -3387.5 { lab=Q5}
N -312.5 -3497.5 -312.5 -3482.5 { lab=VDD}
N -435 -3385 -422.5 -3385 { lab=clk}
N -307.5 -3272.5 -307.5 -3255 { lab=GND}
N -307.5 -3272.5 -305 -3272.5 { lab=GND}
N -297.5 -2957.5 -297.5 -2952.5 { lab=GND}
N -297.5 -2975 -297.5 -2957.5 { lab=GND}
N -427.5 -3097.5 -415 -3097.5 { lab=A}
N -427.5 -3027.5 -415 -3027.5 { lab=B6}
N -297.5 -2977.5 -297.5 -2975 { lab=GND}
N -195 -3067.5 -180 -3067.5 { lab=Q6}
N -305 -3177.5 -305 -3162.5 { lab=VDD}
N -427.5 -3065 -415 -3065 { lab=clk}
N -300 -2952.5 -300 -2935 { lab=GND}
N -300 -2952.5 -297.5 -2952.5 { lab=GND}
N -287.5 -2640 -287.5 -2635 { lab=GND}
N -287.5 -2657.5 -287.5 -2640 { lab=GND}
N -417.5 -2780 -405 -2780 { lab=A}
N -417.5 -2710 -405 -2710 { lab=B7}
N -287.5 -2660 -287.5 -2657.5 { lab=GND}
N -185 -2750 -170 -2750 { lab=Q7}
N -295 -2860 -295 -2845 { lab=VDD}
N -417.5 -2747.5 -405 -2747.5 { lab=clk}
N -290 -2635 -290 -2617.5 { lab=GND}
N -290 -2635 -287.5 -2635 { lab=GND}
N -287.5 -2342.5 -287.5 -2337.5 { lab=GND}
N -287.5 -2360 -287.5 -2342.5 { lab=GND}
N -417.5 -2482.5 -405 -2482.5 { lab=A}
N -417.5 -2412.5 -405 -2412.5 { lab=B8}
N -287.5 -2362.5 -287.5 -2360 { lab=GND}
N -185 -2452.5 -170 -2452.5 { lab=Q8}
N -295 -2562.5 -295 -2547.5 { lab=VDD}
N -417.5 -2450 -405 -2450 { lab=clk}
N -290 -2337.5 -290 -2320 { lab=GND}
N -290 -2337.5 -287.5 -2337.5 { lab=GND}
N -287.5 -1942.5 -287.5 -1937.5 { lab=GND}
N -287.5 -1960 -287.5 -1942.5 { lab=GND}
N -417.5 -2082.5 -405 -2082.5 { lab=A}
N -417.5 -2012.5 -405 -2012.5 { lab=B9}
N -287.5 -1962.5 -287.5 -1960 { lab=GND}
N -185 -2052.5 -170 -2052.5 { lab=Q9}
N -295 -2162.5 -295 -2147.5 { lab=VDD}
N -417.5 -2050 -405 -2050 { lab=clk}
N -290 -1937.5 -290 -1920 { lab=GND}
N -290 -1937.5 -287.5 -1937.5 { lab=GND}
N -287.5 -1645 -287.5 -1640 { lab=GND}
N -287.5 -1662.5 -287.5 -1645 { lab=GND}
N -417.5 -1785 -405 -1785 { lab=A}
N -417.5 -1715 -405 -1715 { lab=B10}
N -287.5 -1665 -287.5 -1662.5 { lab=GND}
N -185 -1755 -170 -1755 { lab=Q10}
N -295 -1865 -295 -1850 { lab=VDD}
N -417.5 -1752.5 -405 -1752.5 { lab=clk}
N -290 -1640 -290 -1622.5 { lab=GND}
N -290 -1640 -287.5 -1640 { lab=GND}
N -285 -1295 -285 -1290 { lab=GND}
N -285 -1312.5 -285 -1295 { lab=GND}
N -415 -1435 -402.5 -1435 { lab=A}
N -415 -1365 -402.5 -1365 { lab=B11}
N -285 -1315 -285 -1312.5 { lab=GND}
N -182.5 -1405 -167.5 -1405 { lab=Q11}
N -292.5 -1515 -292.5 -1500 { lab=VDD}
N -415 -1402.5 -402.5 -1402.5 { lab=clk}
N -287.5 -1290 -287.5 -1272.5 { lab=GND}
N -287.5 -1290 -285 -1290 { lab=GND}
N -285 -997.5 -285 -992.5 { lab=GND}
N -285 -1015 -285 -997.5 { lab=GND}
N -415 -1137.5 -402.5 -1137.5 { lab=A}
N -415 -1067.5 -402.5 -1067.5 { lab=B12}
N -285 -1017.5 -285 -1015 { lab=GND}
N -182.5 -1107.5 -167.5 -1107.5 { lab=Q12}
N -292.5 -1217.5 -292.5 -1202.5 { lab=VDD}
N -415 -1105 -402.5 -1105 { lab=clk}
N -287.5 -992.5 -287.5 -975 { lab=GND}
N -287.5 -992.5 -285 -992.5 { lab=GND}
N -135 -4972.5 -135 -4962.5 { lab=GND}
N -900 -4745 -900 -4735 { lab=GND}
N -900 -4825 -900 -4805 { lab=A}
N -135 -5052.5 -135 -5032.5 { lab=B8}
N -47.5 -4972.5 -47.5 -4962.5 { lab=GND}
N -47.5 -5052.5 -47.5 -5032.5 { lab=B7}
N 32.5 -4972.5 32.5 -4962.5 { lab=GND}
N 32.5 -5052.5 32.5 -5032.5 { lab=B6}
N 117.5 -4970 117.5 -4960 { lab=GND}
N 117.5 -5050 117.5 -5030 { lab=B5}
N 195 -4967.5 195 -4957.5 { lab=GND}
N 195 -5047.5 195 -5027.5 { lab=B4}
N 282.5 -4967.5 282.5 -4957.5 { lab=GND}
N 282.5 -5047.5 282.5 -5027.5 { lab=B3}
N 362.5 -4967.5 362.5 -4957.5 { lab=GND}
N 362.5 -5047.5 362.5 -5027.5 { lab=B2}
N 447.5 -4965 447.5 -4955 { lab=GND}
N 447.5 -5045 447.5 -5025 { lab=B1}
N -307.5 -4972.5 -307.5 -4962.5 { lab=GND}
N -307.5 -5052.5 -307.5 -5032.5 { lab=B10}
N -220 -4972.5 -220 -4962.5 { lab=GND}
N -220 -5052.5 -220 -5032.5 { lab=B9}
N -570 -4975 -570 -4965 { lab=GND}
N -570 -5055 -570 -5035 { lab=B13}
N -482.5 -4975 -482.5 -4965 { lab=GND}
N -482.5 -5055 -482.5 -5035 { lab=B12}
N -402.5 -4975 -402.5 -4965 { lab=GND}
N -402.5 -5055 -402.5 -5035 { lab=B11}
N -742.5 -4975 -742.5 -4965 { lab=GND}
N -742.5 -5055 -742.5 -5035 { lab=B15}
N -655 -4975 -655 -4965 { lab=GND}
N -655 -5055 -655 -5035 { lab=B14}
N -930 -4970 -930 -4960 { lab=GND}
N -930 -5050 -930 -5030 { lab=B17}
N -842.5 -4970 -842.5 -4960 { lab=GND}
N -842.5 -5050 -842.5 -5030 { lab=B16}
N -1025 -4972.5 -1025 -4962.5 { lab=GND}
N -1025 -5052.5 -1025 -5032.5 { lab=B18}
N 265 -3802.5 265 -3797.5 { lab=GND}
N 265 -3820 265 -3802.5 { lab=GND}
N 135 -3942.5 147.5 -3942.5 { lab=A}
N 135 -3872.5 147.5 -3872.5 { lab=B13}
N 265 -3822.5 265 -3820 { lab=GND}
N 367.5 -3912.5 382.5 -3912.5 { lab=Q13}
N 257.5 -4022.5 257.5 -4007.5 { lab=VDD}
N 135 -3910 147.5 -3910 { lab=clk}
N 262.5 -3797.5 262.5 -3780 { lab=GND}
N 262.5 -3797.5 265 -3797.5 { lab=GND}
N 265 -3487.5 265 -3482.5 { lab=GND}
N 265 -3505 265 -3487.5 { lab=GND}
N 135 -3627.5 147.5 -3627.5 { lab=A}
N 135 -3557.5 147.5 -3557.5 { lab=B14}
N 265 -3507.5 265 -3505 { lab=GND}
N 367.5 -3597.5 382.5 -3597.5 { lab=Q14}
N 257.5 -3707.5 257.5 -3692.5 { lab=VDD}
N 135 -3595 147.5 -3595 { lab=clk}
N 262.5 -3482.5 262.5 -3465 { lab=GND}
N 262.5 -3482.5 265 -3482.5 { lab=GND}
N 272.5 -3167.5 272.5 -3162.5 { lab=GND}
N 272.5 -3185 272.5 -3167.5 { lab=GND}
N 142.5 -3307.5 155 -3307.5 { lab=A}
N 142.5 -3237.5 155 -3237.5 { lab=B15}
N 272.5 -3187.5 272.5 -3185 { lab=GND}
N 375 -3277.5 390 -3277.5 { lab=Q15}
N 265 -3387.5 265 -3372.5 { lab=VDD}
N 142.5 -3275 155 -3275 { lab=clk}
N 270 -3162.5 270 -3145 { lab=GND}
N 270 -3162.5 272.5 -3162.5 { lab=GND}
N 282.5 -2850 282.5 -2845 { lab=GND}
N 282.5 -2867.5 282.5 -2850 { lab=GND}
N 152.5 -2990 165 -2990 { lab=A}
N 152.5 -2920 165 -2920 { lab=B16}
N 282.5 -2870 282.5 -2867.5 { lab=GND}
N 385 -2960 400 -2960 { lab=Q16}
N 275 -3070 275 -3055 { lab=VDD}
N 152.5 -2957.5 165 -2957.5 { lab=clk}
N 280 -2845 280 -2827.5 { lab=GND}
N 280 -2845 282.5 -2845 { lab=GND}
N 282.5 -2552.5 282.5 -2547.5 { lab=GND}
N 282.5 -2570 282.5 -2552.5 { lab=GND}
N 152.5 -2692.5 165 -2692.5 { lab=A}
N 152.5 -2622.5 165 -2622.5 { lab=B17}
N 282.5 -2572.5 282.5 -2570 { lab=GND}
N 385 -2662.5 400 -2662.5 { lab=Q17}
N 275 -2772.5 275 -2757.5 { lab=VDD}
N 152.5 -2660 165 -2660 { lab=clk}
N 280 -2547.5 280 -2530 { lab=GND}
N 280 -2547.5 282.5 -2547.5 { lab=GND}
N 282.5 -2152.5 282.5 -2147.5 { lab=GND}
N 282.5 -2170 282.5 -2152.5 { lab=GND}
N 152.5 -2292.5 165 -2292.5 { lab=A}
N 152.5 -2222.5 165 -2222.5 { lab=B18}
N 282.5 -2172.5 282.5 -2170 { lab=GND}
N 385 -2262.5 400 -2262.5 { lab=Q18}
N 275 -2372.5 275 -2357.5 { lab=VDD}
N 152.5 -2260 165 -2260 { lab=clk}
N 280 -2147.5 280 -2130 { lab=GND}
N 280 -2147.5 282.5 -2147.5 { lab=GND}
C {devices/gnd.sym} -1120 -4735 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1120 -4825 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -1120 -4775 0 0 {name=V5 value="pulse 0 1.8 5n .1n .1n 1u 2u"}
C {devices/code.sym} -950 -4635 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.1u 200u
plot A CLK+2 Q1+4 Q2+6 Q3+8 Q4+10 Q5+12 Q6+14 Q7+16 Q8+18 Q9+20 Q10+22 Q11+24 Q12+26 Q13+28 Q14+30 Q15+32 Q16+34 Q17+36 Q18+38
.endc
"}
C {devices/code.sym} -1090 -4635 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice

"}
C {devices/vsource.sym} -1290 -4787.5 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} -1290 -4747.5 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1290 -4837.5 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} -442.5 -4632.5 0 0 {name=l1 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -442.5 -4562.5 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} -442.5 -4600 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -320 -4712.5 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -315 -4470 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -195 -4602.5 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {devices/lab_pin.sym} -440 -4342.5 0 0 {name=l7 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -440 -4272.5 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} -440 -4310 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -317.5 -4422.5 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -312.5 -4180 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -192.5 -4312.5 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} -432.5 -4050 0 0 {name=l25 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -432.5 -3980 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} -432.5 -4017.5 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -310 -4130 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -305 -3887.5 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -185 -4020 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {devices/lab_pin.sym} -435 -3732.5 0 0 {name=l31 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -435 -3662.5 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} -435 -3700 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -312.5 -3812.5 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -307.5 -3570 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -187.5 -3702.5 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {devices/lab_pin.sym} -435 -3417.5 0 0 {name=l37 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -435 -3347.5 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} -435 -3385 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -312.5 -3497.5 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -307.5 -3255 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -187.5 -3387.5 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {devices/lab_pin.sym} -427.5 -3097.5 0 0 {name=l43 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -427.5 -3027.5 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} -427.5 -3065 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -305 -3177.5 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -300 -2935 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -180 -3067.5 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {devices/lab_pin.sym} -417.5 -2780 0 0 {name=l59 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -417.5 -2710 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} -417.5 -2747.5 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -295 -2860 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -290 -2617.5 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} -170 -2750 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {devices/lab_pin.sym} -417.5 -2482.5 0 0 {name=l65 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -417.5 -2412.5 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -417.5 -2450 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -295 -2562.5 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -290 -2320 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -170 -2452.5 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} -417.5 -2082.5 0 0 {name=l71 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -417.5 -2012.5 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} -417.5 -2050 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -295 -2162.5 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -290 -1920 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -170 -2052.5 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {devices/lab_pin.sym} -417.5 -1785 0 0 {name=l77 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -417.5 -1715 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} -417.5 -1752.5 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -295 -1865 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -290 -1622.5 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -170 -1755 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} -415 -1435 0 0 {name=l91 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -415 -1365 0 0 {name=l92 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} -415 -1402.5 0 0 {name=l93 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -292.5 -1515 0 0 {name=l94 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -287.5 -1272.5 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -167.5 -1405 2 0 {name=l96 sig_type=std_logic lab=Q11
}
C {devices/lab_pin.sym} -415 -1137.5 0 0 {name=l97 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -415 -1067.5 0 0 {name=l98 sig_type=std_logic lab=B12}
C {devices/lab_pin.sym} -415 -1105 0 0 {name=l99 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -292.5 -1217.5 0 0 {name=l100 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -287.5 -975 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -167.5 -1107.5 2 0 {name=l102 sig_type=std_logic lab=Q12}
C {cmpoai_all.sym} 730 -1835 0 0 {name=x1}
C {cmpoai_all.sym} 732.5 -1545 0 0 {name=x2}
C {cmpoai_all.sym} 740 -1252.5 0 0 {name=x3}
C {cmpoai_all.sym} 737.5 -935 0 0 {name=x4}
C {cmpoai_all.sym} 737.5 -620 0 0 {name=x5}
C {cmpoai_all.sym} 745 -300 0 0 {name=x6}
C {cmpoai_all.sym} 755 17.5 0 0 {name=x7}
C {cmpoai_all.sym} 755 315 0 0 {name=x8}
C {cmpoai_all.sym} 755 715 0 0 {name=x9}
C {cmpoai_all.sym} 755 1012.5 0 0 {name=x10}
C {cmpoai_all.sym} 757.5 1362.5 0 0 {name=x11}
C {cmpoai_all.sym} 757.5 1660 0 0 {name=x12}
C {devices/vsource.sym} -135 -5002.5 0 0 {name=V16 value=0.75}
C {devices/vsource.sym} -900 -4775 0 0 {name=V17 value="pwl 0 0 12.5u 0 12.5u 0.1 22.5u 0.1 22.5u 0.2 32.5u 0.2 32.5u 0.3 42.5u 0.3 42.5u 0.4 52.5u 0.4 52.5u 0.5 62.5u 0.5 62.5u 0.6 72.5u 0.6 72.5u 0.7 82.5u 0.7 82.5u 0.8 92.5u 0.8 92.5u 0.9 102.5u 0.9 102.5u 1 112.5u 1 112.5u 1.1 122.5u 1.1 122.5u 1.2 132.5u 1.2 132.5u 1.3 142.5u 1.3 142.5u 1.4 152.5u 1.4 152.5u 1.5 162.5u 1.5 162.5u 1.6 172.5u 1.6 172.5u 1.7 182.5u 1.7 182.5u 1.8 192.5u 1.8 192.5u 1.9"}
C {devices/gnd.sym} -900 -4735 0 0 {name=l104 lab=GND}
C {devices/gnd.sym} -135 -4962.5 0 0 {name=l105 lab=GND}
C {devices/lab_pin.sym} -135 -5052.5 0 0 {name=l106 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -900 -4825 0 0 {name=l107 sig_type=std_logic lab=A
}
C {devices/vsource.sym} -47.5 -5002.5 0 0 {name=V19 value=0.65}
C {devices/gnd.sym} -47.5 -4962.5 0 0 {name=l109 lab=GND}
C {devices/lab_pin.sym} -47.5 -5052.5 0 0 {name=l110 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} 32.5 -5002.5 0 0 {name=V20 value=0.55}
C {devices/gnd.sym} 32.5 -4962.5 0 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 32.5 -5052.5 0 0 {name=l112 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} 117.5 -5000 0 0 {name=V21 value=0.45}
C {devices/gnd.sym} 117.5 -4960 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} 117.5 -5050 0 0 {name=l114 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} 195 -4997.5 0 0 {name=V22 value=0.35}
C {devices/gnd.sym} 195 -4957.5 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} 195 -5047.5 0 0 {name=l116 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} 282.5 -4997.5 0 0 {name=V23 value=0.25}
C {devices/gnd.sym} 282.5 -4957.5 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 282.5 -5047.5 0 0 {name=l118 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 362.5 -4997.5 0 0 {name=V24 value=0.15}
C {devices/gnd.sym} 362.5 -4957.5 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} 362.5 -5047.5 0 0 {name=l120 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 447.5 -4995 0 0 {name=V25 value=0.05}
C {devices/gnd.sym} 447.5 -4955 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} 447.5 -5045 0 0 {name=l122 sig_type=std_logic lab=B1
}
C {devices/vsource.sym} -307.5 -5002.5 0 0 {name=V27 value=0.95}
C {devices/gnd.sym} -307.5 -4962.5 0 0 {name=l185 lab=GND}
C {devices/lab_pin.sym} -307.5 -5052.5 0 0 {name=l186 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} -220 -5002.5 0 0 {name=V28 value=0.85}
C {devices/gnd.sym} -220 -4962.5 0 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -220 -5052.5 0 0 {name=l188 sig_type=std_logic lab=B9
}
C {devices/vsource.sym} -570 -5005 0 0 {name=V29 value=1.25}
C {devices/gnd.sym} -570 -4965 0 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} -570 -5055 0 0 {name=l190 sig_type=std_logic lab=B13
}
C {devices/vsource.sym} -482.5 -5005 0 0 {name=V30 value=1.15}
C {devices/gnd.sym} -482.5 -4965 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -482.5 -5055 0 0 {name=l192 sig_type=std_logic lab=B12
}
C {devices/vsource.sym} -402.5 -5005 0 0 {name=V31 value=1.05}
C {devices/gnd.sym} -402.5 -4965 0 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -402.5 -5055 0 0 {name=l194 sig_type=std_logic lab=B11
}
C {devices/vsource.sym} -742.5 -5005 0 0 {name=V32 value=1.45}
C {devices/gnd.sym} -742.5 -4965 0 0 {name=l195 lab=GND}
C {devices/lab_pin.sym} -742.5 -5055 0 0 {name=l196 sig_type=std_logic lab=B15
}
C {devices/vsource.sym} -655 -5005 0 0 {name=V33 value=1.35}
C {devices/gnd.sym} -655 -4965 0 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -655 -5055 0 0 {name=l198 sig_type=std_logic lab=B14
}
C {devices/vsource.sym} -930 -5000 0 0 {name=V34 value=1.65}
C {devices/gnd.sym} -930 -4960 0 0 {name=l199 lab=GND}
C {devices/lab_pin.sym} -930 -5050 0 0 {name=l200 sig_type=std_logic lab=B17
}
C {devices/vsource.sym} -842.5 -5000 0 0 {name=V35 value=1.55}
C {devices/gnd.sym} -842.5 -4960 0 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -842.5 -5050 0 0 {name=l202 sig_type=std_logic lab=B16
}
C {devices/vsource.sym} -1025 -5002.5 0 0 {name=V37 value=1.75}
C {devices/gnd.sym} -1025 -4962.5 0 0 {name=l205 lab=GND}
C {devices/lab_pin.sym} -1025 -5052.5 0 0 {name=l206 sig_type=std_logic lab=B18
}
C {devices/lab_pin.sym} 135 -3942.5 0 0 {name=l219 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 135 -3872.5 0 0 {name=l220 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 135 -3910 0 0 {name=l221 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 257.5 -4022.5 0 0 {name=l222 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 262.5 -3780 0 0 {name=l223 lab=GND}
C {devices/lab_pin.sym} 382.5 -3912.5 2 0 {name=l224 sig_type=std_logic lab=Q13
}
C {devices/lab_pin.sym} 135 -3627.5 0 0 {name=l225 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 135 -3557.5 0 0 {name=l226 sig_type=std_logic lab=B14
}
C {devices/lab_pin.sym} 135 -3595 0 0 {name=l227 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 257.5 -3707.5 0 0 {name=l228 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 262.5 -3465 0 0 {name=l229 lab=GND}
C {devices/lab_pin.sym} 382.5 -3597.5 2 0 {name=l230 sig_type=std_logic lab=Q14
}
C {devices/lab_pin.sym} 142.5 -3307.5 0 0 {name=l231 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 142.5 -3237.5 0 0 {name=l232 sig_type=std_logic lab=B15
}
C {devices/lab_pin.sym} 142.5 -3275 0 0 {name=l233 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 265 -3387.5 0 0 {name=l234 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 270 -3145 0 0 {name=l235 lab=GND}
C {devices/lab_pin.sym} 390 -3277.5 2 0 {name=l236 sig_type=std_logic lab=Q15
}
C {devices/lab_pin.sym} 152.5 -2990 0 0 {name=l237 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 152.5 -2920 0 0 {name=l238 sig_type=std_logic lab=B16
}
C {devices/lab_pin.sym} 152.5 -2957.5 0 0 {name=l239 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 275 -3070 0 0 {name=l240 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 280 -2827.5 0 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} 400 -2960 2 0 {name=l242 sig_type=std_logic lab=Q16
}
C {devices/lab_pin.sym} 152.5 -2692.5 0 0 {name=l243 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 152.5 -2622.5 0 0 {name=l244 sig_type=std_logic lab=B17
}
C {devices/lab_pin.sym} 152.5 -2660 0 0 {name=l245 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 275 -2772.5 0 0 {name=l246 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 280 -2530 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} 400 -2662.5 2 0 {name=l248 sig_type=std_logic lab=Q17}
C {devices/lab_pin.sym} 152.5 -2292.5 0 0 {name=l249 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 152.5 -2222.5 0 0 {name=l250 sig_type=std_logic lab=B18
}
C {devices/lab_pin.sym} 152.5 -2260 0 0 {name=l251 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 275 -2372.5 0 0 {name=l252 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 280 -2130 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} 400 -2262.5 2 0 {name=l254 sig_type=std_logic lab=Q18
}
C {cmpoai_all.sym} 1307.5 -1145 0 0 {name=x13}
C {cmpoai_all.sym} 1307.5 -830 0 0 {name=x14}
C {cmpoai_all.sym} 1315 -510 0 0 {name=x15}
C {cmpoai_all.sym} 1325 -192.5 0 0 {name=x16}
C {cmpoai_all.sym} 1325 105 0 0 {name=x17}
C {cmpoai_all.sym} 1325 505 0 0 {name=x18}
