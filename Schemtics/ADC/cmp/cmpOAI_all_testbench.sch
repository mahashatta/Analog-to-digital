v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 605 -4492.5 605 -4487.5 { lab=GND}
N 605 -4510 605 -4492.5 { lab=GND}
N 475 -4632.5 487.5 -4632.5 { lab=A}
N 475 -4562.5 487.5 -4562.5 { lab=B1}
N 605 -4512.5 605 -4510 { lab=GND}
N 707.5 -4602.5 722.5 -4602.5 { lab=Q1}
N -1120 -4745 -1120 -4735 { lab=GND}
N -1120 -4825 -1120 -4805 { lab=clk}
N -1290 -4757.5 -1290 -4747.5 { lab=GND}
N -1290 -4837.5 -1290 -4817.5 { lab=VDD}
N 597.5 -4712.5 597.5 -4697.5 { lab=VDD}
N 475 -4600 487.5 -4600 { lab=clk}
N 602.5 -4487.5 602.5 -4470 { lab=GND}
N 602.5 -4487.5 605 -4487.5 { lab=GND}
N 607.5 -4202.5 607.5 -4197.5 { lab=GND}
N 607.5 -4220 607.5 -4202.5 { lab=GND}
N 477.5 -4342.5 490 -4342.5 { lab=A}
N 477.5 -4272.5 490 -4272.5 { lab=B2}
N 607.5 -4222.5 607.5 -4220 { lab=GND}
N 710 -4312.5 725 -4312.5 { lab=Q2}
N 600 -4422.5 600 -4407.5 { lab=VDD}
N 477.5 -4310 490 -4310 { lab=clk}
N 605 -4197.5 605 -4180 { lab=GND}
N 605 -4197.5 607.5 -4197.5 { lab=GND}
N 615 -3910 615 -3905 { lab=GND}
N 615 -3927.5 615 -3910 { lab=GND}
N 485 -4050 497.5 -4050 { lab=A}
N 485 -3980 497.5 -3980 { lab=B3}
N 615 -3930 615 -3927.5 { lab=GND}
N 717.5 -4020 732.5 -4020 { lab=Q3}
N 607.5 -4130 607.5 -4115 { lab=VDD}
N 485 -4017.5 497.5 -4017.5 { lab=clk}
N 612.5 -3905 612.5 -3887.5 { lab=GND}
N 612.5 -3905 615 -3905 { lab=GND}
N 612.5 -3592.5 612.5 -3587.5 { lab=GND}
N 612.5 -3610 612.5 -3592.5 { lab=GND}
N 482.5 -3732.5 495 -3732.5 { lab=A}
N 482.5 -3662.5 495 -3662.5 { lab=B4}
N 612.5 -3612.5 612.5 -3610 { lab=GND}
N 715 -3702.5 730 -3702.5 { lab=Q4}
N 605 -3812.5 605 -3797.5 { lab=VDD}
N 482.5 -3700 495 -3700 { lab=clk}
N 610 -3587.5 610 -3570 { lab=GND}
N 610 -3587.5 612.5 -3587.5 { lab=GND}
N 612.5 -3277.5 612.5 -3272.5 { lab=GND}
N 612.5 -3295 612.5 -3277.5 { lab=GND}
N 482.5 -3417.5 495 -3417.5 { lab=A}
N 482.5 -3347.5 495 -3347.5 { lab=B5}
N 612.5 -3297.5 612.5 -3295 { lab=GND}
N 715 -3387.5 730 -3387.5 { lab=Q5}
N 605 -3497.5 605 -3482.5 { lab=VDD}
N 482.5 -3385 495 -3385 { lab=clk}
N 610 -3272.5 610 -3255 { lab=GND}
N 610 -3272.5 612.5 -3272.5 { lab=GND}
N 620 -2957.5 620 -2952.5 { lab=GND}
N 620 -2975 620 -2957.5 { lab=GND}
N 490 -3097.5 502.5 -3097.5 { lab=A}
N 490 -3027.5 502.5 -3027.5 { lab=B6}
N 620 -2977.5 620 -2975 { lab=GND}
N 722.5 -3067.5 737.5 -3067.5 { lab=Q6}
N 612.5 -3177.5 612.5 -3162.5 { lab=VDD}
N 490 -3065 502.5 -3065 { lab=clk}
N 617.5 -2952.5 617.5 -2935 { lab=GND}
N 617.5 -2952.5 620 -2952.5 { lab=GND}
N 630 -2640 630 -2635 { lab=GND}
N 630 -2657.5 630 -2640 { lab=GND}
N 500 -2780 512.5 -2780 { lab=A}
N 500 -2710 512.5 -2710 { lab=B7}
N 630 -2660 630 -2657.5 { lab=GND}
N 732.5 -2750 747.5 -2750 { lab=Q7}
N 622.5 -2860 622.5 -2845 { lab=VDD}
N 500 -2747.5 512.5 -2747.5 { lab=clk}
N 627.5 -2635 627.5 -2617.5 { lab=GND}
N 627.5 -2635 630 -2635 { lab=GND}
N 630 -2342.5 630 -2337.5 { lab=GND}
N 630 -2360 630 -2342.5 { lab=GND}
N 500 -2482.5 512.5 -2482.5 { lab=A}
N 500 -2412.5 512.5 -2412.5 { lab=B8}
N 630 -2362.5 630 -2360 { lab=GND}
N 732.5 -2452.5 747.5 -2452.5 { lab=Q8}
N 622.5 -2562.5 622.5 -2547.5 { lab=VDD}
N 500 -2450 512.5 -2450 { lab=clk}
N 627.5 -2337.5 627.5 -2320 { lab=GND}
N 627.5 -2337.5 630 -2337.5 { lab=GND}
N 630 -1942.5 630 -1937.5 { lab=GND}
N 630 -1960 630 -1942.5 { lab=GND}
N 500 -2082.5 512.5 -2082.5 { lab=A}
N 500 -2012.5 512.5 -2012.5 { lab=B9}
N 630 -1962.5 630 -1960 { lab=GND}
N 732.5 -2052.5 747.5 -2052.5 { lab=Q9}
N 622.5 -2162.5 622.5 -2147.5 { lab=VDD}
N 500 -2050 512.5 -2050 { lab=clk}
N 627.5 -1937.5 627.5 -1920 { lab=GND}
N 627.5 -1937.5 630 -1937.5 { lab=GND}
N 630 -1645 630 -1640 { lab=GND}
N 630 -1662.5 630 -1645 { lab=GND}
N 500 -1785 512.5 -1785 { lab=A}
N 500 -1715 512.5 -1715 { lab=B10}
N 630 -1665 630 -1662.5 { lab=GND}
N 732.5 -1755 747.5 -1755 { lab=Q10}
N 622.5 -1865 622.5 -1850 { lab=VDD}
N 500 -1752.5 512.5 -1752.5 { lab=clk}
N 627.5 -1640 627.5 -1622.5 { lab=GND}
N 627.5 -1640 630 -1640 { lab=GND}
N 632.5 -1295 632.5 -1290 { lab=GND}
N 632.5 -1312.5 632.5 -1295 { lab=GND}
N 502.5 -1435 515 -1435 { lab=A}
N 502.5 -1365 515 -1365 { lab=B11}
N 632.5 -1315 632.5 -1312.5 { lab=GND}
N 735 -1405 750 -1405 { lab=Q11}
N 625 -1515 625 -1500 { lab=VDD}
N 502.5 -1402.5 515 -1402.5 { lab=clk}
N 630 -1290 630 -1272.5 { lab=GND}
N 630 -1290 632.5 -1290 { lab=GND}
N 632.5 -997.5 632.5 -992.5 { lab=GND}
N 632.5 -1015 632.5 -997.5 { lab=GND}
N 502.5 -1137.5 515 -1137.5 { lab=A}
N 502.5 -1067.5 515 -1067.5 { lab=B12}
N 632.5 -1017.5 632.5 -1015 { lab=GND}
N 735 -1107.5 750 -1107.5 { lab=Q12}
N 625 -1217.5 625 -1202.5 { lab=VDD}
N 502.5 -1105 515 -1105 { lab=clk}
N 630 -992.5 630 -975 { lab=GND}
N 630 -992.5 632.5 -992.5 { lab=GND}
N -135 -4972.5 -135 -4962.5 { lab=GND}
N -900 -4745 -900 -4735 { lab=GND}
N -900 -4825 -900 -4805 { lab=A}
N -135 -5052.5 -135 -5032.5 { lab=B8}
N -47.5 -4972.5 -47.5 -4962.5 { lab=GND}
N -47.5 -5052.5 -47.5 -5032.5 { lab=B7}
N 32.5 -4972.5 32.5 -4962.5 { lab=GND}
N 32.5 -5052.5 32.5 -5032.5 { lab=B6}
N 117.5 -4970 117.5 -4960 { lab=GND}
N 117.5 -5050 117.5 -5030 { lab=B5}
N 195 -4967.5 195 -4957.5 { lab=GND}
N 195 -5047.5 195 -5027.5 { lab=B4}
N 282.5 -4967.5 282.5 -4957.5 { lab=GND}
N 282.5 -5047.5 282.5 -5027.5 { lab=B3}
N 362.5 -4967.5 362.5 -4957.5 { lab=GND}
N 362.5 -5047.5 362.5 -5027.5 { lab=B2}
N 447.5 -4965 447.5 -4955 { lab=GND}
N 447.5 -5045 447.5 -5025 { lab=B1}
N -307.5 -4972.5 -307.5 -4962.5 { lab=GND}
N -307.5 -5052.5 -307.5 -5032.5 { lab=B10}
N -220 -4972.5 -220 -4962.5 { lab=GND}
N -220 -5052.5 -220 -5032.5 { lab=B9}
N -482.5 -4975 -482.5 -4965 { lab=GND}
N -482.5 -5055 -482.5 -5035 { lab=B12}
N -402.5 -4975 -402.5 -4965 { lab=GND}
N -402.5 -5055 -402.5 -5035 { lab=B11}
N -635 -4975 -635 -4965 { lab=GND}
N -635 -5055 -635 -5035 { lab=B14}
N -555 -4975 -555 -4965 { lab=GND}
N -555 -5055 -555 -5035 { lab=B13}
N 1082.5 -4075 1082.5 -4070 { lab=GND}
N 1082.5 -4092.5 1082.5 -4075 { lab=GND}
N 952.5 -4215 965 -4215 { lab=A}
N 952.5 -4145 965 -4145 { lab=B13}
N 1082.5 -4095 1082.5 -4092.5 { lab=GND}
N 1185 -4185 1200 -4185 { lab=Q13}
N 1075 -4295 1075 -4280 { lab=VDD}
N 952.5 -4182.5 965 -4182.5 { lab=clk}
N 1080 -4070 1080 -4052.5 { lab=GND}
N 1080 -4070 1082.5 -4070 { lab=GND}
N 1082.5 -3777.5 1082.5 -3772.5 { lab=GND}
N 1082.5 -3795 1082.5 -3777.5 { lab=GND}
N 952.5 -3917.5 965 -3917.5 { lab=A}
N 952.5 -3847.5 965 -3847.5 { lab=B14}
N 1082.5 -3797.5 1082.5 -3795 { lab=GND}
N 1185 -3887.5 1200 -3887.5 { lab=Q14}
N 1075 -3997.5 1075 -3982.5 { lab=VDD}
N 952.5 -3885 965 -3885 { lab=clk}
N 1080 -3772.5 1080 -3755 { lab=GND}
N 1080 -3772.5 1082.5 -3772.5 { lab=GND}
N 582.5 -4705 597.5 -4705 {}
N 590 -4502.5 605 -4502.5 {}
N 585 -4415 600 -4415 {}
N 592.5 -4212.5 607.5 -4212.5 {}
N 592.5 -4122.5 607.5 -4122.5 {}
N 600 -3920 615 -3920 {}
N 590 -3805 605 -3805 {}
N 597.5 -3602.5 612.5 -3602.5 {}
N 590 -3490 605 -3490 {}
N 597.5 -3287.5 612.5 -3287.5 {}
N 597.5 -3170 612.5 -3170 {}
N 605 -2967.5 620 -2967.5 {}
N 607.5 -2852.5 622.5 -2852.5 {}
N 615 -2650 630 -2650 {}
N 607.5 -2555 622.5 -2555 {}
N 615 -2352.5 630 -2352.5 {}
N 607.5 -2155 622.5 -2155 {}
N 615 -1952.5 630 -1952.5 {}
N 607.5 -1857.5 622.5 -1857.5 {}
N 615 -1655 630 -1655 {}
N 610 -1507.5 625 -1507.5 {}
N 617.5 -1305 632.5 -1305 {}
N 610 -1210 625 -1210 {}
N 617.5 -1007.5 632.5 -1007.5 {}
N 1060 -4287.5 1075 -4287.5 {}
N 1067.5 -4085 1082.5 -4085 {}
N 1060 -3990 1075 -3990 {}
N 1067.5 -3787.5 1082.5 -3787.5 {}
N 1082.5 -3425 1082.5 -3420 { lab=GND}
N 1082.5 -3442.5 1082.5 -3425 { lab=GND}
N 952.5 -3565 965 -3565 { lab=A}
N 952.5 -3495 965 -3495 { lab=B13}
N 1082.5 -3445 1082.5 -3442.5 { lab=GND}
N 1185 -3535 1200 -3535 { lab=Q13}
N 1075 -3645 1075 -3630 { lab=VDD}
N 952.5 -3532.5 965 -3532.5 { lab=clk}
N 1080 -3420 1080 -3402.5 { lab=GND}
N 1080 -3420 1082.5 -3420 { lab=GND}
N 1082.5 -3127.5 1082.5 -3122.5 { lab=GND}
N 1082.5 -3145 1082.5 -3127.5 { lab=GND}
N 952.5 -3267.5 965 -3267.5 { lab=A}
N 952.5 -3197.5 965 -3197.5 { lab=B14}
N 1082.5 -3147.5 1082.5 -3145 { lab=GND}
N 1185 -3237.5 1200 -3237.5 { lab=Q14}
N 1075 -3347.5 1075 -3332.5 { lab=VDD}
N 952.5 -3235 965 -3235 { lab=clk}
N 1080 -3122.5 1080 -3105 { lab=GND}
N 1080 -3122.5 1082.5 -3122.5 { lab=GND}
N 1060 -3637.5 1075 -3637.5 {}
N 1067.5 -3435 1082.5 -3435 {}
N 1060 -3340 1075 -3340 {}
N 1067.5 -3137.5 1082.5 -3137.5 {}
N 1082.5 -2762.5 1082.5 -2757.5 { lab=GND}
N 1082.5 -2780 1082.5 -2762.5 { lab=GND}
N 952.5 -2902.5 965 -2902.5 { lab=A}
N 952.5 -2832.5 965 -2832.5 { lab=B13}
N 1082.5 -2782.5 1082.5 -2780 { lab=GND}
N 1185 -2872.5 1200 -2872.5 { lab=Q13}
N 1075 -2982.5 1075 -2967.5 { lab=VDD}
N 952.5 -2870 965 -2870 { lab=clk}
N 1080 -2757.5 1080 -2740 { lab=GND}
N 1080 -2757.5 1082.5 -2757.5 { lab=GND}
N 1082.5 -2465 1082.5 -2460 { lab=GND}
N 1082.5 -2482.5 1082.5 -2465 { lab=GND}
N 952.5 -2605 965 -2605 { lab=A}
N 952.5 -2535 965 -2535 { lab=B14}
N 1082.5 -2485 1082.5 -2482.5 { lab=GND}
N 1185 -2575 1200 -2575 { lab=Q14}
N 1075 -2685 1075 -2670 { lab=VDD}
N 952.5 -2572.5 965 -2572.5 { lab=clk}
N 1080 -2460 1080 -2442.5 { lab=GND}
N 1080 -2460 1082.5 -2460 { lab=GND}
N 1060 -2975 1075 -2975 {}
N 1067.5 -2772.5 1082.5 -2772.5 {}
N 1060 -2677.5 1075 -2677.5 {}
N 1067.5 -2475 1082.5 -2475 {}
N -797.5 -4975 -797.5 -4965 { lab=GND}
N -797.5 -5055 -797.5 -5035 { lab=B12}
N -717.5 -4975 -717.5 -4965 { lab=GND}
N -717.5 -5055 -717.5 -5035 { lab=B11}
N -950 -4975 -950 -4965 { lab=GND}
N -950 -5055 -950 -5035 { lab=B14}
N -870 -4975 -870 -4965 { lab=GND}
N -870 -5055 -870 -5035 { lab=B13}
N -900 -4582.5 -900 -4572.5 { lab=GND}
N -900 -4662.5 -900 -4642.5 { lab=A}
N -900 -4407.5 -900 -4397.5 { lab=GND}
N -900 -4487.5 -900 -4467.5 { lab=A}
N -900 -4252.5 -900 -4242.5 { lab=GND}
N -900 -4332.5 -900 -4312.5 { lab=A}
N -900 -4090 -900 -4080 { lab=GND}
N -900 -4170 -900 -4150 { lab=A}
N -900 -3927.5 -900 -3917.5 { lab=GND}
N -900 -4007.5 -900 -3987.5 { lab=A}
N -900 -3757.5 -900 -3747.5 { lab=GND}
N -900 -3837.5 -900 -3817.5 { lab=A}
N -900 -3617.5 -900 -3607.5 { lab=GND}
N -900 -3697.5 -900 -3677.5 { lab=A}
N -900 -3460 -900 -3450 { lab=GND}
N -900 -3540 -900 -3520 { lab=A}
N -900 -3310 -900 -3300 { lab=GND}
N -900 -3390 -900 -3370 { lab=A}
N -900 -3132.5 -900 -3122.5 { lab=GND}
N -900 -3212.5 -900 -3192.5 { lab=A}
N -900 -2940 -900 -2930 { lab=GND}
N -900 -3020 -900 -3000 { lab=A}
N -900 -2755 -900 -2745 { lab=GND}
N -900 -2835 -900 -2815 { lab=A}
N -900 -2615 -900 -2605 { lab=GND}
N -900 -2695 -900 -2675 { lab=A}
N -900 -2457.5 -900 -2447.5 { lab=GND}
N -900 -2537.5 -900 -2517.5 { lab=A}
N -900 -2307.5 -900 -2297.5 { lab=GND}
N -900 -2387.5 -900 -2367.5 { lab=A}
N -900 -2130 -900 -2120 { lab=GND}
N -900 -2210 -900 -2190 { lab=A}
N -900 -1937.5 -900 -1927.5 { lab=GND}
N -900 -2017.5 -900 -1997.5 { lab=A}
C {devices/gnd.sym} -1120 -4735 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1120 -4825 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -1120 -4775 0 0 {name=V5 value="pulse 0 1.8 2u .1n .1n 2u 4u"}
C {devices/code.sym} -1180 -4640 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.5u 130u
plot Q1 Q2+2 Q3+4 Q4+6 Q5+8 Q6+10 Q7+12 Q8+14 Q9+16 Q10+18 Q11+20 Q12+22 Q13+24 Q14+28 Q15+30 Q16+32 Q17+34 Q18+36 
.endc
"}
C {devices/code.sym} -1320 -4640 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_2.spice

.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a221oi/sky130_fd_sc_hd__a221oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a221oi/sky130_fd_sc_hd__a221oi_4.spice

.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_4.spice


"}
C {devices/vsource.sym} -1290 -4787.5 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} -1290 -4747.5 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1290 -4837.5 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 475 -4632.5 0 0 {name=l1 sig_type=std_logic lab=A1
}
C {devices/lab_pin.sym} 475 -4562.5 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} 475 -4600 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 597.5 -4712.5 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 602.5 -4470 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 722.5 -4602.5 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {devices/lab_pin.sym} 477.5 -4342.5 0 0 {name=l7 sig_type=std_logic lab=A2
}
C {devices/lab_pin.sym} 477.5 -4272.5 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} 477.5 -4310 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 600 -4422.5 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 605 -4180 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 725 -4312.5 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 485 -4050 0 0 {name=l25 sig_type=std_logic lab=A3
}
C {devices/lab_pin.sym} 485 -3980 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} 485 -4017.5 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 607.5 -4130 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 612.5 -3887.5 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} 732.5 -4020 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {devices/lab_pin.sym} 482.5 -3732.5 0 0 {name=l31 sig_type=std_logic lab=A4
}
C {devices/lab_pin.sym} 482.5 -3662.5 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} 482.5 -3700 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 605 -3812.5 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 610 -3570 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 730 -3702.5 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {devices/lab_pin.sym} 482.5 -3417.5 0 0 {name=l37 sig_type=std_logic lab=A5
}
C {devices/lab_pin.sym} 482.5 -3347.5 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} 482.5 -3385 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 605 -3497.5 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 610 -3255 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} 730 -3387.5 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {devices/lab_pin.sym} 490 -3097.5 0 0 {name=l43 sig_type=std_logic lab=A6
}
C {devices/lab_pin.sym} 490 -3027.5 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} 490 -3065 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 612.5 -3177.5 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 617.5 -2935 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} 737.5 -3067.5 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {devices/lab_pin.sym} 500 -2780 0 0 {name=l59 sig_type=std_logic lab=A7
}
C {devices/lab_pin.sym} 500 -2710 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} 500 -2747.5 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 622.5 -2860 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 627.5 -2617.5 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 747.5 -2750 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {devices/lab_pin.sym} 500 -2482.5 0 0 {name=l65 sig_type=std_logic lab=A8
}
C {devices/lab_pin.sym} 500 -2412.5 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} 500 -2450 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 622.5 -2562.5 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 627.5 -2320 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 747.5 -2452.5 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 500 -2082.5 0 0 {name=l71 sig_type=std_logic lab=A9
}
C {devices/lab_pin.sym} 500 -2012.5 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} 500 -2050 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 622.5 -2162.5 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 627.5 -1920 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 747.5 -2052.5 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {devices/lab_pin.sym} 500 -1785 0 0 {name=l77 sig_type=std_logic lab=A10
}
C {devices/lab_pin.sym} 500 -1715 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} 500 -1752.5 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 622.5 -1865 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 627.5 -1622.5 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 747.5 -1755 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 502.5 -1435 0 0 {name=l91 sig_type=std_logic lab=A11
}
C {devices/lab_pin.sym} 502.5 -1365 0 0 {name=l92 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} 502.5 -1402.5 0 0 {name=l93 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 625 -1515 0 0 {name=l94 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 630 -1272.5 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} 750 -1405 2 0 {name=l96 sig_type=std_logic lab=Q11
}
C {devices/lab_pin.sym} 502.5 -1137.5 0 0 {name=l97 sig_type=std_logic lab=A12
}
C {devices/lab_pin.sym} 502.5 -1067.5 0 0 {name=l98 sig_type=std_logic lab=B12}
C {devices/lab_pin.sym} 502.5 -1105 0 0 {name=l99 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 625 -1217.5 0 0 {name=l100 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 630 -975 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} 750 -1107.5 2 0 {name=l102 sig_type=std_logic lab=Q12}
C {devices/vsource.sym} -135 -5002.5 0 0 {name=V16 value=0.7}
C {devices/vsource.sym} -900 -4775 0 0 {name=V17 value="pwl 0 0 12.5u 0 12.5u 0.01 22.5u 0.01 22.5u 0.02 32.5u 0.02 32.5u 0.03 42.5u 0.03 42.5u 0.04 52.5u 0.04 52.5u 0.05 62.5u 0.05 62.5u 0.06 72.5u 0.06 72.5u 0.07 82.5u 0.07 82.5u 0.08 92.5u 0.08 92.5u 0.09 102.5u 0.09 102.5u 0.1 112.5u 0.1 "}
C {devices/gnd.sym} -900 -4735 0 0 {name=l104 lab=GND}
C {devices/gnd.sym} -135 -4962.5 0 0 {name=l105 lab=GND}
C {devices/lab_pin.sym} -135 -5052.5 0 0 {name=l106 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -900 -4825 0 0 {name=l107 sig_type=std_logic lab=A1
}
C {devices/vsource.sym} -47.5 -5002.5 0 0 {name=V19 value=0.6}
C {devices/gnd.sym} -47.5 -4962.5 0 0 {name=l109 lab=GND}
C {devices/lab_pin.sym} -47.5 -5052.5 0 0 {name=l110 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} 32.5 -5002.5 0 0 {name=V20 value=0.5}
C {devices/gnd.sym} 32.5 -4962.5 0 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 32.5 -5052.5 0 0 {name=l112 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} 117.5 -5000 0 0 {name=V21 value=0.4}
C {devices/gnd.sym} 117.5 -4960 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} 117.5 -5050 0 0 {name=l114 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} 195 -4997.5 0 0 {name=V22 value=0.3}
C {devices/gnd.sym} 195 -4957.5 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} 195 -5047.5 0 0 {name=l116 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} 282.5 -4997.5 0 0 {name=V23 value=0.2}
C {devices/gnd.sym} 282.5 -4957.5 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 282.5 -5047.5 0 0 {name=l118 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 362.5 -4997.5 0 0 {name=V24 value=0.1}
C {devices/gnd.sym} 362.5 -4957.5 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} 362.5 -5047.5 0 0 {name=l120 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 447.5 -4995 0 0 {name=V25 value=0}
C {devices/gnd.sym} 447.5 -4955 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} 447.5 -5045 0 0 {name=l122 sig_type=std_logic lab=B1
}
C {devices/vsource.sym} -307.5 -5002.5 0 0 {name=V27 value=0.9}
C {devices/gnd.sym} -307.5 -4962.5 0 0 {name=l185 lab=GND}
C {devices/lab_pin.sym} -307.5 -5052.5 0 0 {name=l186 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} -220 -5002.5 0 0 {name=V28 value=0.8}
C {devices/gnd.sym} -220 -4962.5 0 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -220 -5052.5 0 0 {name=l188 sig_type=std_logic lab=B9
}
C {devices/vsource.sym} -482.5 -5005 0 0 {name=V30 value=1.1}
C {devices/gnd.sym} -482.5 -4965 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -482.5 -5055 0 0 {name=l192 sig_type=std_logic lab=B12
}
C {devices/vsource.sym} -402.5 -5005 0 0 {name=V31 value=1.0}
C {devices/gnd.sym} -402.5 -4965 0 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -402.5 -5055 0 0 {name=l194 sig_type=std_logic lab=B11
}
C {devices/vsource.sym} -635 -5005 0 0 {name=V1 value=1.3}
C {devices/gnd.sym} -635 -4965 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -635 -5055 0 0 {name=l9 sig_type=std_logic lab=B14
}
C {devices/vsource.sym} -555 -5005 0 0 {name=V2 value=1.2}
C {devices/gnd.sym} -555 -4965 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -555 -5055 0 0 {name=l12 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 952.5 -4215 0 0 {name=l13 sig_type=std_logic lab=A13
}
C {devices/lab_pin.sym} 952.5 -4145 0 0 {name=l14 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 952.5 -4182.5 0 0 {name=l15 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -4295 0 0 {name=l17 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -4052.5 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 1200 -4185 2 0 {name=l19 sig_type=std_logic lab=Q13
}
C {devices/lab_pin.sym} 952.5 -3917.5 0 0 {name=l45 sig_type=std_logic lab=A14
}
C {devices/lab_pin.sym} 952.5 -3847.5 0 0 {name=l46 sig_type=std_logic lab=B14}
C {devices/lab_pin.sym} 952.5 -3885 0 0 {name=l47 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -3997.5 0 0 {name=l48 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -3755 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 1200 -3887.5 2 0 {name=l50 sig_type=std_logic lab=Q14}
C {cmpoai_all_.sym} 2057.5 -265 0 0 {name=x1}
C {cmpoai_all_.sym} 2060 25 0 0 {name=x2}
C {cmpoai_all_.sym} 2067.5 317.5 0 0 {name=x3}
C {cmpoai_all_.sym} 2065 635 0 0 {name=x4}
C {cmpoai_all_.sym} 2065 950 0 0 {name=x5}
C {cmpoai_all_.sym} 2072.5 1270 0 0 {name=x6}
C {cmpoai_all_.sym} 2082.5 1587.5 0 0 {name=x7}
C {cmpoai_all_.sym} 2082.5 1885 0 0 {name=x8}
C {cmpoai_all_.sym} 2082.5 2285 0 0 {name=x9}
C {cmpoai_all_.sym} 2082.5 2582.5 0 0 {name=x10}
C {cmpoai_all_.sym} 2085 2932.5 0 0 {name=x11}
C {cmpoai_all_.sym} 2085 3230 0 0 {name=x12}
C {cmpoai_all_.sym} 2535 450 0 0 {name=x13}
C {cmpoai_all_.sym} 2535 152.5 0 0 {name=x14}
C {devices/lab_pin.sym} 952.5 -3565 0 0 {name=l51 sig_type=std_logic lab=A15
}
C {devices/lab_pin.sym} 952.5 -3495 0 0 {name=l52 sig_type=std_logic lab=B15
}
C {devices/lab_pin.sym} 952.5 -3532.5 0 0 {name=l83 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -3645 0 0 {name=l84 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -3402.5 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} 1200 -3535 2 0 {name=l86 sig_type=std_logic lab=Q15
}
C {devices/lab_pin.sym} 952.5 -3267.5 0 0 {name=l87 sig_type=std_logic lab=A16
}
C {devices/lab_pin.sym} 952.5 -3197.5 0 0 {name=l88 sig_type=std_logic lab=B16}
C {devices/lab_pin.sym} 952.5 -3235 0 0 {name=l89 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -3347.5 0 0 {name=l90 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -3105 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} 1200 -3237.5 2 0 {name=l108 sig_type=std_logic lab=Q16}
C {cmpoai_all_.sym} 2535 1100 0 0 {name=x15}
C {cmpoai_all_.sym} 2535 802.5 0 0 {name=x16}
C {devices/lab_pin.sym} 952.5 -2902.5 0 0 {name=l123 sig_type=std_logic lab=A17
}
C {devices/lab_pin.sym} 952.5 -2832.5 0 0 {name=l124 sig_type=std_logic lab=B17
}
C {devices/lab_pin.sym} 952.5 -2870 0 0 {name=l125 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -2982.5 0 0 {name=l126 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -2740 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} 1200 -2872.5 2 0 {name=l128 sig_type=std_logic lab=Q17
}
C {devices/lab_pin.sym} 952.5 -2605 0 0 {name=l129 sig_type=std_logic lab=A18
}
C {devices/lab_pin.sym} 952.5 -2535 0 0 {name=l130 sig_type=std_logic lab=B18}
C {devices/lab_pin.sym} 952.5 -2572.5 0 0 {name=l131 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 1075 -2685 0 0 {name=l132 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 1080 -2442.5 0 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} 1200 -2575 2 0 {name=l134 sig_type=std_logic lab=Q18}
C {cmpoai_all_.sym} 2535 1762.5 0 0 {name=x17}
C {cmpoai_all_.sym} 2535 1465 0 0 {name=x18}
C {devices/vsource.sym} -797.5 -5005 0 0 {name=V3 value=1.5}
C {devices/gnd.sym} -797.5 -4965 0 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} -797.5 -5055 0 0 {name=l136 sig_type=std_logic lab=B16
}
C {devices/vsource.sym} -717.5 -5005 0 0 {name=V4 value=1.4}
C {devices/gnd.sym} -717.5 -4965 0 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -717.5 -5055 0 0 {name=l138 sig_type=std_logic lab=B15
}
C {devices/vsource.sym} -950 -5005 0 0 {name=V6 value=1.7}
C {devices/gnd.sym} -950 -4965 0 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} -950 -5055 0 0 {name=l140 sig_type=std_logic lab=B18
}
C {devices/vsource.sym} -870 -5005 0 0 {name=V7 value=1.6}
C {devices/gnd.sym} -870 -4965 0 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -870 -5055 0 0 {name=l142 sig_type=std_logic lab=B17
}
C {devices/vsource.sym} -900 -4612.5 0 0 {name=V8 value="pwl 0 0.1 12.5u 0.1 12.5u 0.11 22.5u 0.11 22.5u 0.12 32.5u 0.12 32.5u 0.13 42.5u 0.13 42.5u 0.14 52.5u 0.14 52.5u 0.15 62.5u 0.15 62.5u 0.16 72.5u 0.16 72.5u 0.17 82.5u 0.17 82.5u 0.18 92.5u 0.18 92.5u 0.19 102.5u 0.19 102.5u 0.2 112.5u 0.2 "}
C {devices/gnd.sym} -900 -4572.5 0 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} -900 -4662.5 0 0 {name=l144 sig_type=std_logic lab=A2
}
C {devices/vsource.sym} -900 -4437.5 0 0 {name=V9 value="pwl 0 0.2 12.5u 0.2 12.5u 0.21 22.5u 0.21 22.5u 0.22 32.5u 0.22 32.5u 0.23 42.5u 0.23 42.5u 0.24 52.5u 0.24 52.5u 0.25 62.5u 0.25 62.5u 0.26 72.5u 0.26 72.5u 0.27 82.5u 0.27 82.5u 0.28 92.5u 0.28 92.5u 0.29 102.5u 0.29 102.5u 0.3 112.5u 0.3"}
C {devices/gnd.sym} -900 -4397.5 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -900 -4487.5 0 0 {name=l146 sig_type=std_logic lab=A3}
C {devices/vsource.sym} -900 -4282.5 0 0 {name=V10 value="pwl 0 0.3 12.5u 0.3 12.5u 0.31 22.5u 0.31 22.5u 0.32 32.5u 0.32 32.5u 0.33 42.5u 0.33 42.5u 0.34 52.5u 0.34 52.5u 0.35 62.5u 0.35 62.5u 0.36 72.5u 0.36 72.5u 0.37 82.5u 0.37 82.5u 0.38 92.5u 0.38 92.5u 0.39 102.5u 0.39 102.5u 0.4 112.5u 0.4"}
C {devices/gnd.sym} -900 -4242.5 0 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} -900 -4332.5 0 0 {name=l148 sig_type=std_logic lab=A4
}
C {devices/vsource.sym} -900 -4120 0 0 {name=V12 value="pwl 0 0.4 12.5u 0.4 12.5u 0.41 22.5u 0.41 22.5u 0.42 32.5u 0.42 32.5u 0.43 42.5u 0.43 42.5u 0.44 52.5u 0.44 52.5u 0.45 62.5u 0.45 62.5u 0.46 72.5u 0.46 72.5u 0.47 82.5u 0.47 82.5u 0.48 92.5u 0.48 92.5u 0.49 102.5u 0.49 102.5u 0.5 112.5u 0.5 "}
C {devices/gnd.sym} -900 -4080 0 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} -900 -4170 0 0 {name=l150 sig_type=std_logic lab=A5
}
C {devices/vsource.sym} -900 -3957.5 0 0 {name=V13 value="pwl 0 0.5 12.5u 0.5 12.5u 0.51 22.5u 0.51 22.5u 0.52 32.5u 0.52 32.5u 0.53 42.5u 0.53 42.5u 0.54 52.5u 0.54 52.5u 0.55 62.5u 0.55 62.5u 0.56 72.5u 0.56 72.5u 0.57 82.5u 0.57 82.5u 0.58 92.5u 0.58 92.5u 0.59 102.5u 0.59 102.5u 0.6 112.5u 0.6 "}
C {devices/gnd.sym} -900 -3917.5 0 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} -900 -4007.5 0 0 {name=l152 sig_type=std_logic lab=A6
}
C {devices/vsource.sym} -900 -3787.5 0 0 {name=V14 value="pwl 0 0.6 12.5u 0.6 12.5u 0.61 22.5u 0.61 22.5u 0.62 32.5u 0.62 32.5u 0.63 42.5u 0.63 42.5u 0.64 52.5u 0.64 52.5u 0.65 62.5u 0.65 62.5u 0.66 72.5u 0.66 72.5u 0.67 82.5u 0.67 82.5u 0.68 92.5u 0.68 92.5u 0.69 102.5u 0.69 102.5u 0.7 112.5u 0.7 "}
C {devices/gnd.sym} -900 -3747.5 0 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} -900 -3837.5 0 0 {name=l154 sig_type=std_logic lab=A7
}
C {devices/vsource.sym} -900 -3647.5 0 0 {name=V15 value="pwl 0 0.7 12.5u 0.7 12.5u 0.71 22.5u 0.71 22.5u 0.72 32.5u 0.72 32.5u 0.73 42.5u 0.73 42.5u 0.74 52.5u 0.74 52.5u 0.75 62.5u 0.75 62.5u 0.76 72.5u 0.76 72.5u 0.77 82.5u 0.77 82.5u 0.78 92.5u 0.78 92.5u 0.79 102.5u 0.79 102.5u 0.8 112.5u 0.8 "}
C {devices/gnd.sym} -900 -3607.5 0 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} -900 -3697.5 0 0 {name=l156 sig_type=std_logic lab=A8
}
C {devices/vsource.sym} -900 -3490 0 0 {name=V18 value="pwl 0 .8 12.5u 0.8 12.5u 0.81 22.5u 0.81 22.5u 0.82 32.5u 0.82 32.5u 0.83 42.5u 0.83 42.5u 0.84 52.5u 0.84 52.5u 0.85 62.5u 0.85 62.5u 0.86 72.5u 0.86 72.5u 0.87 82.5u 0.87 82.5u 0.88 92.5u 0.88 92.5u 0.89 102.5u 0.89 102.5u 0.9 112.5u 0.9 "}
C {devices/gnd.sym} -900 -3450 0 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -900 -3540 0 0 {name=l158 sig_type=std_logic lab=A9
}
C {devices/vsource.sym} -900 -3340 0 0 {name=V26 value="pwl 0 0.9 12.5u 0.9 12.5u 0.91 22.5u 0.91 22.5u 0.92 32.5u 0.92 32.5u 0.93 42.5u 0.93 42.5u 0.94 52.5u 0.94 52.5u 0.95 62.5u 0.95 62.5u 0.96 72.5u 0.96 72.5u 0.97 82.5u 0.97 82.5u 0.98 92.5u 0.98 92.5u 0.99 102.5u 0.99 102.5u 1.0 112.5u 1.0 "}
C {devices/gnd.sym} -900 -3300 0 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} -900 -3390 0 0 {name=l160 sig_type=std_logic lab=A10
}
C {devices/vsource.sym} -900 -3162.5 0 0 {name=V29 value="pwl 0 1.0 12.5u 1.0 12.5u 1.01 22.5u 1.01 22.5u 1.02 32.5u 1.02 32.5u 1.03 42.5u 1.03 42.5u 1.04 52.5u 1.04 52.5u 1.05 62.5u 1.05 62.5u 1.06 72.5u 1.06 72.5u 1.07 82.5u 1.07 82.5u 1.08 92.5u 1.08 92.5u 1.09 102.5u 1.09 102.5u 1.1 112.5u 1.1 "}
C {devices/gnd.sym} -900 -3122.5 0 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -900 -3212.5 0 0 {name=l162 sig_type=std_logic lab=A11
}
C {devices/vsource.sym} -900 -2970 0 0 {name=V32 value="pwl 0 1.1 12.5u 1.1 12.5u 1.11 22.5u 1.11 22.5u 1.12 32.5u 1.12 32.5u 1.13 42.5u 1.13 42.5u 1.14 52.5u 1.14 52.5u 1.15 62.5u 1.15 62.5u 1.16 72.5u 1.16 72.5u 1.17 82.5u 1.17 82.5u 1.18 92.5u 1.18 92.5u 1.19 102.5u 1.19 102.5u 1.2 112.5u 1.2 "}
C {devices/gnd.sym} -900 -2930 0 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} -900 -3020 0 0 {name=l164 sig_type=std_logic lab=A12
}
C {devices/gnd.sym} -900 -2745 0 0 {name=l165 lab=GND}
C {devices/lab_pin.sym} -900 -2835 0 0 {name=l166 sig_type=std_logic lab=A13
}
C {devices/gnd.sym} -900 -2605 0 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} -900 -2695 0 0 {name=l168 sig_type=std_logic lab=A14
}
C {devices/gnd.sym} -900 -2447.5 0 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} -900 -2537.5 0 0 {name=l170 sig_type=std_logic lab=A15
}
C {devices/gnd.sym} -900 -2297.5 0 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} -900 -2387.5 0 0 {name=l172 sig_type=std_logic lab=A16
}
C {devices/gnd.sym} -900 -2120 0 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} -900 -2210 0 0 {name=l174 sig_type=std_logic lab=A17
}
C {devices/gnd.sym} -900 -1927.5 0 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} -900 -2017.5 0 0 {name=l176 sig_type=std_logic lab=A18
}
C {devices/vsource.sym} -900 -2785 0 0 {name=V33 value="pwl 0 1.2 12.5u 1.2 12.5u 1.21 22.5u 1.21 22.5u 1.22 32.5u 1.22 32.5u 1.23 42.5u 1.23 42.5u 1.24 52.5u 1.24 52.5u 1.25 62.5u 1.25 62.5u 1.26 72.5u 1.26 72.5u 1.27 82.5u 1.27 82.5u 1.28 92.5u 1.28 92.5u 1.29 102.5u 1.29 102.5u 1.3 112.5u 1.3 "}
C {devices/vsource.sym} -900 -2645 0 0 {name=V34 value="pwl 0 1.3 12.5u 1.3 12.5u 1.31 22.5u 1.31 22.5u 1.32 32.5u 1.32 32.5u 1.33 42.5u 1.33 42.5u 1.34 52.5u 1.34 52.5u 1.35 62.5u 1.35 62.5u 1.36 72.5u 1.36 72.5u 1.37 82.5u 1.37 82.5u 1.38 92.5u 1.38 92.5u 1.39 102.5u 1.39 102.5u 1.4 112.5u 1.4 "}
C {devices/vsource.sym} -900 -2487.5 0 0 {name=V35 value="pwl 0 1.4 12.5u 1.4 12.5u 1.41 22.5u 1.41 22.5u 1.42 32.5u 1.42 32.5u 1.43 42.5u 1.43 42.5u 1.44 52.5u 1.44 52.5u 1.45 62.5u 1.45 62.5u 1.46 72.5u 1.46 72.5u 1.47 82.5u 1.47 82.5u 1.48 92.5u 1.48 92.5u 1.49 102.5u 1.49 102.5u 1.5 112.5u 1.5 "}
C {devices/vsource.sym} -900 -2337.5 0 0 {name=V36 value="pwl 0 1.5 12.5u 1.5 12.5u 1.51 22.5u 1.51 22.5u 1.52 32.5u 1.52 32.5u 1.53 42.5u 1.53 42.5u 1.54 52.5u 1.54 52.5u 1.55 62.5u 1.55 62.5u 1.56 72.5u 1.56 72.5u 1.57 82.5u 1.57 82.5u 1.58 92.5u 1.58 92.5u 1.59 102.5u 1.59 102.5u 1.6 112.5u 1.6 "}
C {devices/vsource.sym} -900 -2160 0 0 {name=V37 value="pwl 0 1.6 12.5u 1.6 12.5u 1.61 22.5u 1.61 22.5u 1.62 32.5u 1.62 32.5u 1.63 42.5u 1.63 42.5u 1.64 52.5u 1.64 52.5u 1.65 62.5u 1.65 62.5u 1.66 72.5u 1.66 72.5u 1.67 82.5u 1.67 82.5u 1.68 92.5u 1.68 92.5u 1.69 102.5u 1.69 102.5u 1.7 112.5u 1.7 "}
C {devices/vsource.sym} -900 -1967.5 0 0 {name=V38 value="pwl 0 1.7 12.5u 1.7 12.5u 1.71 22.5u 1.71 22.5u 1.72 32.5u 1.72 32.5u 1.73 42.5u 1.73 42.5u 1.74 52.5u 1.74 52.5u 1.75 62.5u 1.75 62.5u 1.76 72.5u 1.76 72.5u 1.77 82.5u 1.77 82.5u 1.78 92.5u 1.78 92.5u 1.79 102.5u 1.79 102.5u 1.8 112.5u 1.8 "}
