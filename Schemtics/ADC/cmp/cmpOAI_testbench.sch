v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -140 -1575 -140 -1570 { lab=GND}
N -140 -1592.5 -140 -1575 { lab=GND}
N -270 -1715 -257.5 -1715 { lab=A}
N -270 -1645 -257.5 -1645 { lab=B1}
N -140 -1595 -140 -1592.5 { lab=GND}
N -37.5 -1685 -22.5 -1685 { lab=Q1}
N -255 -1982.5 -255 -1972.5 { lab=GND}
N -727.5 -1827.5 -727.5 -1817.5 { lab=GND}
N -947.5 -1827.5 -947.5 -1817.5 { lab=GND}
N -947.5 -1907.5 -947.5 -1887.5 { lab=clk}
N -727.5 -1907.5 -727.5 -1887.5 { lab=A}
N -255 -2062.5 -255 -2042.5 { lab=B8}
N -167.5 -1982.5 -167.5 -1972.5 { lab=GND}
N -167.5 -2062.5 -167.5 -2042.5 { lab=B7}
N -87.5 -1982.5 -87.5 -1972.5 { lab=GND}
N -87.5 -2062.5 -87.5 -2042.5 { lab=B6}
N -2.5 -1980 -2.5 -1970 { lab=GND}
N -2.5 -2060 -2.5 -2040 { lab=B5}
N 75 -1977.5 75 -1967.5 { lab=GND}
N 75 -2057.5 75 -2037.5 { lab=B4}
N 162.5 -1977.5 162.5 -1967.5 { lab=GND}
N 162.5 -2057.5 162.5 -2037.5 { lab=B3}
N 242.5 -1977.5 242.5 -1967.5 { lab=GND}
N 242.5 -2057.5 242.5 -2037.5 { lab=B2}
N 327.5 -1975 327.5 -1965 { lab=GND}
N 327.5 -2055 327.5 -2035 { lab=B1}
N -1117.5 -1840 -1117.5 -1830 { lab=GND}
N -1117.5 -1920 -1117.5 -1900 { lab=VDD}
N -147.5 -1795 -147.5 -1780 { lab=VDD}
N -270 -1682.5 -257.5 -1682.5 { lab=clk}
N -142.5 -1570 -142.5 -1552.5 { lab=GND}
N -142.5 -1570 -140 -1570 { lab=GND}
N -137.5 -1285 -137.5 -1280 { lab=GND}
N -137.5 -1302.5 -137.5 -1285 { lab=GND}
N -267.5 -1425 -255 -1425 { lab=A}
N -267.5 -1355 -255 -1355 { lab=B2}
N -137.5 -1305 -137.5 -1302.5 { lab=GND}
N -35 -1395 -20 -1395 { lab=Q2}
N -145 -1505 -145 -1490 { lab=VDD}
N -267.5 -1392.5 -255 -1392.5 { lab=clk}
N -140 -1280 -140 -1262.5 { lab=GND}
N -140 -1280 -137.5 -1280 { lab=GND}
N -130 -992.5 -130 -987.5 { lab=GND}
N -130 -1010 -130 -992.5 { lab=GND}
N -260 -1132.5 -247.5 -1132.5 { lab=A}
N -260 -1062.5 -247.5 -1062.5 { lab=B3}
N -130 -1012.5 -130 -1010 { lab=GND}
N -27.5 -1102.5 -12.5 -1102.5 { lab=Q3}
N -137.5 -1212.5 -137.5 -1197.5 { lab=VDD}
N -260 -1100 -247.5 -1100 { lab=clk}
N -132.5 -987.5 -132.5 -970 { lab=GND}
N -132.5 -987.5 -130 -987.5 { lab=GND}
N -132.5 -675 -132.5 -670 { lab=GND}
N -132.5 -692.5 -132.5 -675 { lab=GND}
N -262.5 -815 -250 -815 { lab=A}
N -262.5 -745 -250 -745 { lab=B4}
N -132.5 -695 -132.5 -692.5 { lab=GND}
N -30 -785 -15 -785 { lab=Q4}
N -140 -895 -140 -880 { lab=VDD}
N -262.5 -782.5 -250 -782.5 { lab=clk}
N -135 -670 -135 -652.5 { lab=GND}
N -135 -670 -132.5 -670 { lab=GND}
N -132.5 -360 -132.5 -355 { lab=GND}
N -132.5 -377.5 -132.5 -360 { lab=GND}
N -262.5 -500 -250 -500 { lab=A}
N -262.5 -430 -250 -430 { lab=B5}
N -132.5 -380 -132.5 -377.5 { lab=GND}
N -30 -470 -15 -470 { lab=Q5}
N -140 -580 -140 -565 { lab=VDD}
N -262.5 -467.5 -250 -467.5 { lab=clk}
N -135 -355 -135 -337.5 { lab=GND}
N -135 -355 -132.5 -355 { lab=GND}
N -125 -40 -125 -35 { lab=GND}
N -125 -57.5 -125 -40 { lab=GND}
N -255 -180 -242.5 -180 { lab=A}
N -255 -110 -242.5 -110 { lab=B6}
N -125 -60 -125 -57.5 { lab=GND}
N -22.5 -150 -7.5 -150 { lab=Q6}
N -132.5 -260 -132.5 -245 { lab=VDD}
N -255 -147.5 -242.5 -147.5 { lab=clk}
N -127.5 -35 -127.5 -17.5 { lab=GND}
N -127.5 -35 -125 -35 { lab=GND}
N -115 277.5 -115 282.5 { lab=GND}
N -115 260 -115 277.5 { lab=GND}
N -245 137.5 -232.5 137.5 { lab=A}
N -245 207.5 -232.5 207.5 { lab=B7}
N -115 257.5 -115 260 { lab=GND}
N -12.5 167.5 2.5 167.5 { lab=Q7}
N -122.5 57.5 -122.5 72.5 { lab=VDD}
N -245 170 -232.5 170 { lab=clk}
N -117.5 282.5 -117.5 300 { lab=GND}
N -117.5 282.5 -115 282.5 { lab=GND}
N -115 575 -115 580 { lab=GND}
N -115 557.5 -115 575 { lab=GND}
N -245 435 -232.5 435 { lab=A}
N -245 505 -232.5 505 { lab=B8}
N -115 555 -115 557.5 { lab=GND}
N -12.5 465 2.5 465 { lab=Q8}
N -122.5 355 -122.5 370 { lab=VDD}
N -245 467.5 -232.5 467.5 { lab=clk}
N -117.5 580 -117.5 597.5 { lab=GND}
N -117.5 580 -115 580 { lab=GND}
N -115 975 -115 980 { lab=GND}
N -115 957.5 -115 975 { lab=GND}
N -245 835 -232.5 835 { lab=A}
N -245 905 -232.5 905 { lab=B9}
N -115 955 -115 957.5 { lab=GND}
N -12.5 865 2.5 865 { lab=Q9}
N -122.5 755 -122.5 770 { lab=VDD}
N -245 867.5 -232.5 867.5 { lab=clk}
N -117.5 980 -117.5 997.5 { lab=GND}
N -117.5 980 -115 980 { lab=GND}
N -115 1272.5 -115 1277.5 { lab=GND}
N -115 1255 -115 1272.5 { lab=GND}
N -245 1132.5 -232.5 1132.5 { lab=A}
N -245 1202.5 -232.5 1202.5 { lab=B10}
N -115 1252.5 -115 1255 { lab=GND}
N -12.5 1162.5 2.5 1162.5 { lab=Q10}
N -122.5 1052.5 -122.5 1067.5 { lab=VDD}
N -245 1165 -232.5 1165 { lab=clk}
N -117.5 1277.5 -117.5 1295 { lab=GND}
N -117.5 1277.5 -115 1277.5 { lab=GND}
N -427.5 -1982.5 -427.5 -1972.5 { lab=GND}
N -427.5 -2062.5 -427.5 -2042.5 { lab=B10}
N -340 -1982.5 -340 -1972.5 { lab=GND}
N -340 -2062.5 -340 -2042.5 { lab=B9}
N -690 -1985 -690 -1975 { lab=GND}
N -690 -2065 -690 -2045 { lab=B13}
N -602.5 -1985 -602.5 -1975 { lab=GND}
N -602.5 -2065 -602.5 -2045 { lab=B12}
N -522.5 -1985 -522.5 -1975 { lab=GND}
N -522.5 -2065 -522.5 -2045 { lab=B11}
N -862.5 -1985 -862.5 -1975 { lab=GND}
N -862.5 -2065 -862.5 -2045 { lab=B15}
N -775 -1985 -775 -1975 { lab=GND}
N -775 -2065 -775 -2045 { lab=B14}
N -1050 -1980 -1050 -1970 { lab=GND}
N -1050 -2060 -1050 -2040 { lab=B17}
N -962.5 -1980 -962.5 -1970 { lab=GND}
N -962.5 -2060 -962.5 -2040 { lab=B16}
N -1232.5 -1982.5 -1232.5 -1972.5 { lab=GND}
N -1232.5 -2062.5 -1232.5 -2042.5 { lab=B19}
N -1145 -1982.5 -1145 -1972.5 { lab=GND}
N -1145 -2062.5 -1145 -2042.5 { lab=B18}
N 435 -1470 435 -1465 { lab=GND}
N 435 -1487.5 435 -1470 { lab=GND}
N 305 -1610 317.5 -1610 { lab=A}
N 305 -1540 317.5 -1540 { lab=B11}
N 435 -1490 435 -1487.5 { lab=GND}
N 537.5 -1580 552.5 -1580 { lab=Q11}
N 427.5 -1690 427.5 -1675 { lab=VDD}
N 305 -1577.5 317.5 -1577.5 { lab=clk}
N 432.5 -1465 432.5 -1447.5 { lab=GND}
N 432.5 -1465 435 -1465 { lab=GND}
N 442.5 -1177.5 442.5 -1172.5 { lab=GND}
N 442.5 -1195 442.5 -1177.5 { lab=GND}
N 312.5 -1317.5 325 -1317.5 { lab=A}
N 312.5 -1247.5 325 -1247.5 { lab=B12}
N 442.5 -1197.5 442.5 -1195 { lab=GND}
N 545 -1287.5 560 -1287.5 { lab=Q12}
N 435 -1397.5 435 -1382.5 { lab=VDD}
N 312.5 -1285 325 -1285 { lab=clk}
N 440 -1172.5 440 -1155 { lab=GND}
N 440 -1172.5 442.5 -1172.5 { lab=GND}
N 440 -860 440 -855 { lab=GND}
N 440 -877.5 440 -860 { lab=GND}
N 310 -1000 322.5 -1000 { lab=A}
N 310 -930 322.5 -930 { lab=B13}
N 440 -880 440 -877.5 { lab=GND}
N 542.5 -970 557.5 -970 { lab=Q13}
N 432.5 -1080 432.5 -1065 { lab=VDD}
N 310 -967.5 322.5 -967.5 { lab=clk}
N 437.5 -855 437.5 -837.5 { lab=GND}
N 437.5 -855 440 -855 { lab=GND}
N 440 -545 440 -540 { lab=GND}
N 440 -562.5 440 -545 { lab=GND}
N 310 -685 322.5 -685 { lab=A}
N 310 -615 322.5 -615 { lab=B14}
N 440 -565 440 -562.5 { lab=GND}
N 542.5 -655 557.5 -655 { lab=Q14}
N 432.5 -765 432.5 -750 { lab=VDD}
N 310 -652.5 322.5 -652.5 { lab=clk}
N 437.5 -540 437.5 -522.5 { lab=GND}
N 437.5 -540 440 -540 { lab=GND}
N 447.5 -225 447.5 -220 { lab=GND}
N 447.5 -242.5 447.5 -225 { lab=GND}
N 317.5 -365 330 -365 { lab=A}
N 317.5 -295 330 -295 { lab=B15}
N 447.5 -245 447.5 -242.5 { lab=GND}
N 550 -335 565 -335 { lab=Q15}
N 440 -445 440 -430 { lab=VDD}
N 317.5 -332.5 330 -332.5 { lab=clk}
N 445 -220 445 -202.5 { lab=GND}
N 445 -220 447.5 -220 { lab=GND}
N 457.5 92.5 457.5 97.5 { lab=GND}
N 457.5 75 457.5 92.5 { lab=GND}
N 327.5 -47.5 340 -47.5 { lab=A}
N 327.5 22.5 340 22.5 { lab=B16}
N 457.5 72.5 457.5 75 { lab=GND}
N 560 -17.5 575 -17.5 { lab=Q16}
N 450 -127.5 450 -112.5 { lab=VDD}
N 327.5 -15 340 -15 { lab=clk}
N 455 97.5 455 115 { lab=GND}
N 455 97.5 457.5 97.5 { lab=GND}
N 457.5 390 457.5 395 { lab=GND}
N 457.5 372.5 457.5 390 { lab=GND}
N 327.5 250 340 250 { lab=A}
N 327.5 320 340 320 { lab=B17}
N 457.5 370 457.5 372.5 { lab=GND}
N 560 280 575 280 { lab=Q17}
N 450 170 450 185 { lab=VDD}
N 327.5 282.5 340 282.5 { lab=clk}
N 455 395 455 412.5 { lab=GND}
N 455 395 457.5 395 { lab=GND}
N 457.5 790 457.5 795 { lab=GND}
N 457.5 772.5 457.5 790 { lab=GND}
N 327.5 650 340 650 { lab=A}
N 327.5 720 340 720 { lab=B18}
N 457.5 770 457.5 772.5 { lab=GND}
N 560 680 575 680 { lab=Q18}
N 450 570 450 585 { lab=VDD}
N 327.5 682.5 340 682.5 { lab=clk}
N 455 795 455 812.5 { lab=GND}
N 455 795 457.5 795 { lab=GND}
N 457.5 1087.5 457.5 1092.5 { lab=GND}
N 457.5 1070 457.5 1087.5 { lab=GND}
N 327.5 947.5 340 947.5 { lab=A}
N 327.5 1017.5 340 1017.5 { lab=B19}
N 457.5 1067.5 457.5 1070 { lab=GND}
N 560 977.5 575 977.5 { lab=Q19}
N 450 867.5 450 882.5 { lab=VDD}
N 327.5 980 340 980 { lab=clk}
N 455 1092.5 455 1110 { lab=GND}
N 455 1092.5 457.5 1092.5 { lab=GND}
C {devices/vsource.sym} -255 -2012.5 0 0 {name=V3 value=0.425}
C {devices/vsource.sym} -727.5 -1857.5 0 0 {name=V4 value="pwl 0 0 12.5u 0 12.5u 0.1 12.5u 0.025 22.5u 0.025 22.5u 0.075 32.5u 0.075 32.5u 0.125 42.5u 0.125 42.5u 0.175 52.5u 0.175 52.5u 0.225 62.5u 0.225 62.5u 0.275 72.5u 0.275 72.5u 0.325 82.5u 0.325 82.5u 0.375 92.5u 0.375 92.5u 0.425 102.5u 0.425 102.5u 0.475 112.5u 0.475 112.5u 0.525 122.5u 0.525 122.5u 0.575 132.5u 0.575 132.5u 0.625 142.5u 0.625 142.5u 0.675 152.5u 0.675 152.5u 0.725 162.5u 0.725 162.5u 0.775 172.5u 0.775 172.5u 0.825 182.5u 0.825 182.5u 0.875 192.5u 0.875 192.5u 0.925 202.5u 0.925 202.5u 0.975" "}
C {devices/gnd.sym} -947.5 -1817.5 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} -727.5 -1817.5 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -255 -1972.5 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -255 -2062.5 0 0 {name=l14 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -727.5 -1907.5 0 0 {name=l15 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -947.5 -1907.5 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} -947.5 -1857.5 0 0 {name=V5 value="pulse 0 1.8 5n .1n .1n 1u 2u"}
C {devices/code.sym} -777.5 -1717.5 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.1u 210u
plot A CLK+2 Q1+4 Q2+6 Q3+8 Q4+10 Q5+12 Q6+14 Q7+16 Q8+18 Q9+20 Q10+22 Q11+24 Q12+26 Q13+28 Q14+30 Q15+32 Q16+34 Q17+36 Q18+38 Q19+40
.endc
"}
C {devices/vsource.sym} -167.5 -2012.5 0 0 {name=V1 value=0.375}
C {devices/gnd.sym} -167.5 -1972.5 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -167.5 -2062.5 0 0 {name=l9 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} -87.5 -2012.5 0 0 {name=V2 value=0.325}
C {devices/gnd.sym} -87.5 -1972.5 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -87.5 -2062.5 0 0 {name=l17 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} -2.5 -2010 0 0 {name=V6 value=0.275}
C {devices/gnd.sym} -2.5 -1970 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2.5 -2060 0 0 {name=l19 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} 75 -2007.5 0 0 {name=V7 value=0.225}
C {devices/gnd.sym} 75 -1967.5 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} 75 -2057.5 0 0 {name=l46 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} 162.5 -2007.5 0 0 {name=V8 value=0.175}
C {devices/gnd.sym} 162.5 -1967.5 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} 162.5 -2057.5 0 0 {name=l48 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 242.5 -2007.5 0 0 {name=V9 value=0.125}
C {devices/gnd.sym} 242.5 -1967.5 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 242.5 -2057.5 0 0 {name=l50 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 327.5 -2005 0 0 {name=V10 value=0.075}
C {devices/gnd.sym} 327.5 -1965 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} 327.5 -2055 0 0 {name=l52 sig_type=std_logic lab=B1
}
C {devices/code.sym} -917.5 -1717.5 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice

"}
C {devices/vsource.sym} -1117.5 -1870 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} -1117.5 -1830 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1117.5 -1920 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {cmpoaisch.sym} 162.5 -760 0 0 {name=x1}
C {devices/lab_pin.sym} -270 -1715 0 0 {name=l1 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -270 -1645 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} -270 -1682.5 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -147.5 -1795 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -142.5 -1552.5 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -22.5 -1685 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {cmpoaisch.sym} 165 -470 0 0 {name=x2}
C {devices/lab_pin.sym} -267.5 -1425 0 0 {name=l7 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -267.5 -1355 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} -267.5 -1392.5 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -145 -1505 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -140 -1262.5 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -20 -1395 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {cmpoaisch.sym} 172.5 -177.5 0 0 {name=x3}
C {devices/lab_pin.sym} -260 -1132.5 0 0 {name=l25 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -260 -1062.5 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} -260 -1100 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -137.5 -1212.5 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -132.5 -970 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -12.5 -1102.5 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {cmpoaisch.sym} 170 140 0 0 {name=x4}
C {devices/lab_pin.sym} -262.5 -815 0 0 {name=l31 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -262.5 -745 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} -262.5 -782.5 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -140 -895 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -135 -652.5 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -15 -785 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {cmpoaisch.sym} 170 455 0 0 {name=x5}
C {devices/lab_pin.sym} -262.5 -500 0 0 {name=l37 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -262.5 -430 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} -262.5 -467.5 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -140 -580 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -135 -337.5 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -15 -470 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {cmpoaisch.sym} 177.5 775 0 0 {name=x6}
C {devices/lab_pin.sym} -255 -180 0 0 {name=l43 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -255 -110 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} -255 -147.5 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -132.5 -260 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -127.5 -17.5 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -7.5 -150 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {cmpoaisch.sym} 187.5 1092.5 0 0 {name=x7}
C {devices/lab_pin.sym} -245 137.5 0 0 {name=l59 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 207.5 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} -245 170 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 57.5 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 300 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 2.5 167.5 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {cmpoaisch.sym} 187.5 1390 0 0 {name=x8}
C {devices/lab_pin.sym} -245 435 0 0 {name=l65 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 505 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} -245 467.5 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 355 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 597.5 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 2.5 465 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {cmpoaisch.sym} 187.5 1790 0 0 {name=x9}
C {devices/lab_pin.sym} -245 835 0 0 {name=l71 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 905 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} -245 867.5 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 755 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 997.5 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 2.5 865 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {cmpoaisch.sym} 187.5 2087.5 0 0 {name=x10}
C {devices/lab_pin.sym} -245 1132.5 0 0 {name=l77 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} -245 1202.5 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} -245 1165 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} -122.5 1052.5 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} -117.5 1295 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 2.5 1162.5 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/vsource.sym} -427.5 -2012.5 0 0 {name=V12 value=0.525}
C {devices/gnd.sym} -427.5 -1972.5 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -427.5 -2062.5 0 0 {name=l84 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} -340 -2012.5 0 0 {name=V13 value=0.475}
C {devices/gnd.sym} -340 -1972.5 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -340 -2062.5 0 0 {name=l86 sig_type=std_logic lab=B9
}
C {devices/vsource.sym} -690 -2015 0 0 {name=V14 value=0.675}
C {devices/gnd.sym} -690 -1975 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -690 -2065 0 0 {name=l88 sig_type=std_logic lab=B13
}
C {devices/vsource.sym} -602.5 -2015 0 0 {name=V15 value=0.625}
C {devices/gnd.sym} -602.5 -1975 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -602.5 -2065 0 0 {name=l90 sig_type=std_logic lab=B12
}
C {devices/vsource.sym} -522.5 -2015 0 0 {name=V16 value=0.575}
C {devices/gnd.sym} -522.5 -1975 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} -522.5 -2065 0 0 {name=l92 sig_type=std_logic lab=B11
}
C {devices/vsource.sym} -862.5 -2015 0 0 {name=V17 value=0.775}
C {devices/gnd.sym} -862.5 -1975 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -862.5 -2065 0 0 {name=l94 sig_type=std_logic lab=B15
}
C {devices/vsource.sym} -775 -2015 0 0 {name=V18 value=0.725}
C {devices/gnd.sym} -775 -1975 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -775 -2065 0 0 {name=l96 sig_type=std_logic lab=B14
}
C {devices/vsource.sym} -1050 -2010 0 0 {name=V19 value=0.875}
C {devices/gnd.sym} -1050 -1970 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} -1050 -2060 0 0 {name=l98 sig_type=std_logic lab=B17
}
C {devices/vsource.sym} -962.5 -2010 0 0 {name=V20 value=0.825}
C {devices/gnd.sym} -962.5 -1970 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -962.5 -2060 0 0 {name=l100 sig_type=std_logic lab=B16
}
C {devices/vsource.sym} -1232.5 -2012.5 0 0 {name=V21 value=0.975}
C {devices/gnd.sym} -1232.5 -1972.5 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -1232.5 -2062.5 0 0 {name=l102 sig_type=std_logic lab=B19
}
C {devices/vsource.sym} -1145 -2012.5 0 0 {name=V22 value=0.925}
C {devices/gnd.sym} -1145 -1972.5 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -1145 -2062.5 0 0 {name=l104 sig_type=std_logic lab=B18
}
C {cmpoaisch.sym} 737.5 -655 0 0 {name=x11}
C {devices/lab_pin.sym} 305 -1610 0 0 {name=l105 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 305 -1540 0 0 {name=l106 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} 305 -1577.5 0 0 {name=l107 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 427.5 -1690 0 0 {name=l108 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 432.5 -1447.5 0 0 {name=l109 lab=GND}
C {devices/lab_pin.sym} 552.5 -1580 2 0 {name=l110 sig_type=std_logic lab=Q11}
C {cmpoaisch.sym} 745 -362.5 0 0 {name=x12}
C {devices/lab_pin.sym} 312.5 -1317.5 0 0 {name=l111 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 312.5 -1247.5 0 0 {name=l112 sig_type=std_logic lab=B12
}
C {devices/lab_pin.sym} 312.5 -1285 0 0 {name=l113 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 435 -1397.5 0 0 {name=l114 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 440 -1155 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} 560 -1287.5 2 0 {name=l116 sig_type=std_logic lab=Q12
}
C {cmpoaisch.sym} 742.5 -45 0 0 {name=x13}
C {devices/lab_pin.sym} 310 -1000 0 0 {name=l117 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 310 -930 0 0 {name=l118 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 310 -967.5 0 0 {name=l119 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 432.5 -1080 0 0 {name=l120 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 437.5 -837.5 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} 557.5 -970 2 0 {name=l122 sig_type=std_logic lab=Q13
}
C {cmpoaisch.sym} 742.5 270 0 0 {name=x14}
C {devices/lab_pin.sym} 310 -685 0 0 {name=l123 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 310 -615 0 0 {name=l124 sig_type=std_logic lab=B14
}
C {devices/lab_pin.sym} 310 -652.5 0 0 {name=l125 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 432.5 -765 0 0 {name=l126 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 437.5 -522.5 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} 557.5 -655 2 0 {name=l128 sig_type=std_logic lab=Q14
}
C {cmpoaisch.sym} 750 590 0 0 {name=x15}
C {devices/lab_pin.sym} 317.5 -365 0 0 {name=l129 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 317.5 -295 0 0 {name=l130 sig_type=std_logic lab=B15
}
C {devices/lab_pin.sym} 317.5 -332.5 0 0 {name=l131 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 440 -445 0 0 {name=l132 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 445 -202.5 0 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} 565 -335 2 0 {name=l134 sig_type=std_logic lab=Q15
}
C {cmpoaisch.sym} 760 907.5 0 0 {name=x16}
C {devices/lab_pin.sym} 327.5 -47.5 0 0 {name=l135 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 327.5 22.5 0 0 {name=l136 sig_type=std_logic lab=B16
}
C {devices/lab_pin.sym} 327.5 -15 0 0 {name=l137 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 450 -127.5 0 0 {name=l138 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 455 115 0 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} 575 -17.5 2 0 {name=l140 sig_type=std_logic lab=Q16
}
C {cmpoaisch.sym} 760 1205 0 0 {name=x17}
C {devices/lab_pin.sym} 327.5 250 0 0 {name=l141 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 327.5 320 0 0 {name=l142 sig_type=std_logic lab=B17
}
C {devices/lab_pin.sym} 327.5 282.5 0 0 {name=l143 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 450 170 0 0 {name=l144 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 455 412.5 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} 575 280 2 0 {name=l146 sig_type=std_logic lab=Q17}
C {cmpoaisch.sym} 760 1605 0 0 {name=x18}
C {devices/lab_pin.sym} 327.5 650 0 0 {name=l147 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 327.5 720 0 0 {name=l148 sig_type=std_logic lab=B18
}
C {devices/lab_pin.sym} 327.5 682.5 0 0 {name=l149 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 450 570 0 0 {name=l150 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 455 812.5 0 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} 575 680 2 0 {name=l152 sig_type=std_logic lab=Q18
}
C {cmpoaisch.sym} 760 1902.5 0 0 {name=x19}
C {devices/lab_pin.sym} 327.5 947.5 0 0 {name=l153 sig_type=std_logic lab=A
}
C {devices/lab_pin.sym} 327.5 1017.5 0 0 {name=l154 sig_type=std_logic lab=B19
}
C {devices/lab_pin.sym} 327.5 980 0 0 {name=l155 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 450 867.5 0 0 {name=l156 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 455 1110 0 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} 575 977.5 2 0 {name=l158 sig_type=std_logic lab=Q19}
