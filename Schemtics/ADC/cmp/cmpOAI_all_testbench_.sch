v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 2275 -5212.5 2275 -5207.5 { lab=GND}
N 2275 -5230 2275 -5212.5 { lab=GND}
N 2145 -5352.5 2157.5 -5352.5 { lab=A}
N 2145 -5282.5 2157.5 -5282.5 { lab=B1}
N 2275 -5232.5 2275 -5230 { lab=GND}
N 2377.5 -5322.5 2392.5 -5322.5 { lab=Q1}
N 550 -5465 550 -5455 { lab=GND}
N 550 -5545 550 -5525 { lab=clk}
N 380 -5477.5 380 -5467.5 { lab=GND}
N 380 -5557.5 380 -5537.5 { lab=VDD}
N 2267.5 -5432.5 2267.5 -5417.5 { lab=VDD}
N 2145 -5320 2157.5 -5320 { lab=clk}
N 2272.5 -5207.5 2272.5 -5190 { lab=GND}
N 2272.5 -5207.5 2275 -5207.5 { lab=GND}
N 2277.5 -4922.5 2277.5 -4917.5 { lab=GND}
N 2277.5 -4940 2277.5 -4922.5 { lab=GND}
N 2147.5 -5062.5 2160 -5062.5 { lab=A}
N 2147.5 -4992.5 2160 -4992.5 { lab=B2}
N 2277.5 -4942.5 2277.5 -4940 { lab=GND}
N 2380 -5032.5 2395 -5032.5 { lab=Q2}
N 2270 -5142.5 2270 -5127.5 { lab=VDD}
N 2147.5 -5030 2160 -5030 { lab=clk}
N 2275 -4917.5 2275 -4900 { lab=GND}
N 2275 -4917.5 2277.5 -4917.5 { lab=GND}
N 2285 -4630 2285 -4625 { lab=GND}
N 2285 -4647.5 2285 -4630 { lab=GND}
N 2155 -4770 2167.5 -4770 { lab=A}
N 2155 -4700 2167.5 -4700 { lab=B3}
N 2285 -4650 2285 -4647.5 { lab=GND}
N 2387.5 -4740 2402.5 -4740 { lab=Q3}
N 2277.5 -4850 2277.5 -4835 { lab=VDD}
N 2155 -4737.5 2167.5 -4737.5 { lab=clk}
N 2282.5 -4625 2282.5 -4607.5 { lab=GND}
N 2282.5 -4625 2285 -4625 { lab=GND}
N 2282.5 -4312.5 2282.5 -4307.5 { lab=GND}
N 2282.5 -4330 2282.5 -4312.5 { lab=GND}
N 2152.5 -4452.5 2165 -4452.5 { lab=A}
N 2152.5 -4382.5 2165 -4382.5 { lab=B4}
N 2282.5 -4332.5 2282.5 -4330 { lab=GND}
N 2385 -4422.5 2400 -4422.5 { lab=Q4}
N 2275 -4532.5 2275 -4517.5 { lab=VDD}
N 2152.5 -4420 2165 -4420 { lab=clk}
N 2280 -4307.5 2280 -4290 { lab=GND}
N 2280 -4307.5 2282.5 -4307.5 { lab=GND}
N 2282.5 -3997.5 2282.5 -3992.5 { lab=GND}
N 2282.5 -4015 2282.5 -3997.5 { lab=GND}
N 2152.5 -4137.5 2165 -4137.5 { lab=A}
N 2152.5 -4067.5 2165 -4067.5 { lab=B5}
N 2282.5 -4017.5 2282.5 -4015 { lab=GND}
N 2385 -4107.5 2400 -4107.5 { lab=Q5}
N 2275 -4217.5 2275 -4202.5 { lab=VDD}
N 2152.5 -4105 2165 -4105 { lab=clk}
N 2280 -3992.5 2280 -3975 { lab=GND}
N 2280 -3992.5 2282.5 -3992.5 { lab=GND}
N 2290 -3677.5 2290 -3672.5 { lab=GND}
N 2290 -3695 2290 -3677.5 { lab=GND}
N 2160 -3817.5 2172.5 -3817.5 { lab=A}
N 2160 -3747.5 2172.5 -3747.5 { lab=B6}
N 2290 -3697.5 2290 -3695 { lab=GND}
N 2392.5 -3787.5 2407.5 -3787.5 { lab=Q6}
N 2282.5 -3897.5 2282.5 -3882.5 { lab=VDD}
N 2160 -3785 2172.5 -3785 { lab=clk}
N 2287.5 -3672.5 2287.5 -3655 { lab=GND}
N 2287.5 -3672.5 2290 -3672.5 { lab=GND}
N 2300 -3360 2300 -3355 { lab=GND}
N 2300 -3377.5 2300 -3360 { lab=GND}
N 2170 -3500 2182.5 -3500 { lab=A}
N 2170 -3430 2182.5 -3430 { lab=B7}
N 2300 -3380 2300 -3377.5 { lab=GND}
N 2402.5 -3470 2417.5 -3470 { lab=Q7}
N 2292.5 -3580 2292.5 -3565 { lab=VDD}
N 2170 -3467.5 2182.5 -3467.5 { lab=clk}
N 2297.5 -3355 2297.5 -3337.5 { lab=GND}
N 2297.5 -3355 2300 -3355 { lab=GND}
N 2300 -3062.5 2300 -3057.5 { lab=GND}
N 2300 -3080 2300 -3062.5 { lab=GND}
N 2170 -3202.5 2182.5 -3202.5 { lab=A}
N 2170 -3132.5 2182.5 -3132.5 { lab=B8}
N 2300 -3082.5 2300 -3080 { lab=GND}
N 2402.5 -3172.5 2417.5 -3172.5 { lab=Q8}
N 2292.5 -3282.5 2292.5 -3267.5 { lab=VDD}
N 2170 -3170 2182.5 -3170 { lab=clk}
N 2297.5 -3057.5 2297.5 -3040 { lab=GND}
N 2297.5 -3057.5 2300 -3057.5 { lab=GND}
N 2300 -2662.5 2300 -2657.5 { lab=GND}
N 2300 -2680 2300 -2662.5 { lab=GND}
N 2170 -2802.5 2182.5 -2802.5 { lab=A}
N 2170 -2732.5 2182.5 -2732.5 { lab=B9}
N 2300 -2682.5 2300 -2680 { lab=GND}
N 2402.5 -2772.5 2417.5 -2772.5 { lab=Q9}
N 2292.5 -2882.5 2292.5 -2867.5 { lab=VDD}
N 2170 -2770 2182.5 -2770 { lab=clk}
N 2297.5 -2657.5 2297.5 -2640 { lab=GND}
N 2297.5 -2657.5 2300 -2657.5 { lab=GND}
N 2300 -2365 2300 -2360 { lab=GND}
N 2300 -2382.5 2300 -2365 { lab=GND}
N 2170 -2505 2182.5 -2505 { lab=A}
N 2170 -2435 2182.5 -2435 { lab=B10}
N 2300 -2385 2300 -2382.5 { lab=GND}
N 2402.5 -2475 2417.5 -2475 { lab=Q10}
N 2292.5 -2585 2292.5 -2570 { lab=VDD}
N 2170 -2472.5 2182.5 -2472.5 { lab=clk}
N 2297.5 -2360 2297.5 -2342.5 { lab=GND}
N 2297.5 -2360 2300 -2360 { lab=GND}
N 2302.5 -2015 2302.5 -2010 { lab=GND}
N 2302.5 -2032.5 2302.5 -2015 { lab=GND}
N 2172.5 -2155 2185 -2155 { lab=A}
N 2172.5 -2085 2185 -2085 { lab=B11}
N 2302.5 -2035 2302.5 -2032.5 { lab=GND}
N 2405 -2125 2420 -2125 { lab=Q11}
N 2295 -2235 2295 -2220 { lab=VDD}
N 2172.5 -2122.5 2185 -2122.5 { lab=clk}
N 2300 -2010 2300 -1992.5 { lab=GND}
N 2300 -2010 2302.5 -2010 { lab=GND}
N 2302.5 -1717.5 2302.5 -1712.5 { lab=GND}
N 2302.5 -1735 2302.5 -1717.5 { lab=GND}
N 2172.5 -1857.5 2185 -1857.5 { lab=A}
N 2172.5 -1787.5 2185 -1787.5 { lab=B12}
N 2302.5 -1737.5 2302.5 -1735 { lab=GND}
N 2405 -1827.5 2420 -1827.5 { lab=Q12}
N 2295 -1937.5 2295 -1922.5 { lab=VDD}
N 2172.5 -1825 2185 -1825 { lab=clk}
N 2300 -1712.5 2300 -1695 { lab=GND}
N 2300 -1712.5 2302.5 -1712.5 { lab=GND}
N 1535 -5692.5 1535 -5682.5 { lab=GND}
N 770 -5465 770 -5455 { lab=GND}
N 770 -5545 770 -5525 { lab=A}
N 1535 -5772.5 1535 -5752.5 { lab=B8}
N 1622.5 -5692.5 1622.5 -5682.5 { lab=GND}
N 1622.5 -5772.5 1622.5 -5752.5 { lab=B7}
N 1702.5 -5692.5 1702.5 -5682.5 { lab=GND}
N 1702.5 -5772.5 1702.5 -5752.5 { lab=B6}
N 1787.5 -5690 1787.5 -5680 { lab=GND}
N 1787.5 -5770 1787.5 -5750 { lab=B5}
N 1865 -5687.5 1865 -5677.5 { lab=GND}
N 1865 -5767.5 1865 -5747.5 { lab=B4}
N 1952.5 -5687.5 1952.5 -5677.5 { lab=GND}
N 1952.5 -5767.5 1952.5 -5747.5 { lab=B3}
N 2032.5 -5687.5 2032.5 -5677.5 { lab=GND}
N 2032.5 -5767.5 2032.5 -5747.5 { lab=B2}
N 2117.5 -5685 2117.5 -5675 { lab=GND}
N 2117.5 -5765 2117.5 -5745 { lab=B1}
N 1362.5 -5692.5 1362.5 -5682.5 { lab=GND}
N 1362.5 -5772.5 1362.5 -5752.5 { lab=B10}
N 1450 -5692.5 1450 -5682.5 { lab=GND}
N 1450 -5772.5 1450 -5752.5 { lab=B9}
N 1187.5 -5695 1187.5 -5685 { lab=GND}
N 1187.5 -5775 1187.5 -5755 { lab=B12}
N 1267.5 -5695 1267.5 -5685 { lab=GND}
N 1267.5 -5775 1267.5 -5755 { lab=B11}
N 1035 -5695 1035 -5685 { lab=GND}
N 1035 -5775 1035 -5755 { lab=B14}
N 1115 -5695 1115 -5685 { lab=GND}
N 1115 -5775 1115 -5755 { lab=B13}
N 2752.5 -4795 2752.5 -4790 { lab=GND}
N 2752.5 -4812.5 2752.5 -4795 { lab=GND}
N 2622.5 -4935 2635 -4935 { lab=A}
N 2622.5 -4865 2635 -4865 { lab=B13}
N 2752.5 -4815 2752.5 -4812.5 { lab=GND}
N 2855 -4905 2870 -4905 { lab=Q13}
N 2745 -5015 2745 -5000 { lab=VDD}
N 2622.5 -4902.5 2635 -4902.5 { lab=clk}
N 2750 -4790 2750 -4772.5 { lab=GND}
N 2750 -4790 2752.5 -4790 { lab=GND}
N 2752.5 -4497.5 2752.5 -4492.5 { lab=GND}
N 2752.5 -4515 2752.5 -4497.5 { lab=GND}
N 2622.5 -4637.5 2635 -4637.5 { lab=A}
N 2622.5 -4567.5 2635 -4567.5 { lab=B14}
N 2752.5 -4517.5 2752.5 -4515 { lab=GND}
N 2855 -4607.5 2870 -4607.5 { lab=Q14}
N 2745 -4717.5 2745 -4702.5 { lab=VDD}
N 2622.5 -4605 2635 -4605 { lab=clk}
N 2750 -4492.5 2750 -4475 { lab=GND}
N 2750 -4492.5 2752.5 -4492.5 { lab=GND}
N 2252.5 -5425 2267.5 -5425 {}
N 2260 -5222.5 2275 -5222.5 {}
N 2255 -5135 2270 -5135 {}
N 2262.5 -4932.5 2277.5 -4932.5 {}
N 2262.5 -4842.5 2277.5 -4842.5 {}
N 2270 -4640 2285 -4640 {}
N 2260 -4525 2275 -4525 {}
N 2267.5 -4322.5 2282.5 -4322.5 {}
N 2260 -4210 2275 -4210 {}
N 2267.5 -4007.5 2282.5 -4007.5 {}
N 2267.5 -3890 2282.5 -3890 {}
N 2275 -3687.5 2290 -3687.5 {}
N 2277.5 -3572.5 2292.5 -3572.5 {}
N 2285 -3370 2300 -3370 {}
N 2277.5 -3275 2292.5 -3275 {}
N 2285 -3072.5 2300 -3072.5 {}
N 2277.5 -2875 2292.5 -2875 {}
N 2285 -2672.5 2300 -2672.5 {}
N 2277.5 -2577.5 2292.5 -2577.5 {}
N 2285 -2375 2300 -2375 {}
N 2280 -2227.5 2295 -2227.5 {}
N 2287.5 -2025 2302.5 -2025 {}
N 2280 -1930 2295 -1930 {}
N 2287.5 -1727.5 2302.5 -1727.5 {}
N 2730 -5007.5 2745 -5007.5 {}
N 2737.5 -4805 2752.5 -4805 {}
N 2730 -4710 2745 -4710 {}
N 2737.5 -4507.5 2752.5 -4507.5 {}
N 2752.5 -4145 2752.5 -4140 { lab=GND}
N 2752.5 -4162.5 2752.5 -4145 { lab=GND}
N 2622.5 -4285 2635 -4285 { lab=A}
N 2622.5 -4215 2635 -4215 { lab=B13}
N 2752.5 -4165 2752.5 -4162.5 { lab=GND}
N 2855 -4255 2870 -4255 { lab=Q13}
N 2745 -4365 2745 -4350 { lab=VDD}
N 2622.5 -4252.5 2635 -4252.5 { lab=clk}
N 2750 -4140 2750 -4122.5 { lab=GND}
N 2750 -4140 2752.5 -4140 { lab=GND}
N 2752.5 -3847.5 2752.5 -3842.5 { lab=GND}
N 2752.5 -3865 2752.5 -3847.5 { lab=GND}
N 2622.5 -3987.5 2635 -3987.5 { lab=A}
N 2622.5 -3917.5 2635 -3917.5 { lab=B14}
N 2752.5 -3867.5 2752.5 -3865 { lab=GND}
N 2855 -3957.5 2870 -3957.5 { lab=Q14}
N 2745 -4067.5 2745 -4052.5 { lab=VDD}
N 2622.5 -3955 2635 -3955 { lab=clk}
N 2750 -3842.5 2750 -3825 { lab=GND}
N 2750 -3842.5 2752.5 -3842.5 { lab=GND}
N 2730 -4357.5 2745 -4357.5 {}
N 2737.5 -4155 2752.5 -4155 {}
N 2730 -4060 2745 -4060 {}
N 2737.5 -3857.5 2752.5 -3857.5 {}
N 2752.5 -3482.5 2752.5 -3477.5 { lab=GND}
N 2752.5 -3500 2752.5 -3482.5 { lab=GND}
N 2622.5 -3622.5 2635 -3622.5 { lab=A}
N 2622.5 -3552.5 2635 -3552.5 { lab=B13}
N 2752.5 -3502.5 2752.5 -3500 { lab=GND}
N 2855 -3592.5 2870 -3592.5 { lab=Q13}
N 2745 -3702.5 2745 -3687.5 { lab=VDD}
N 2622.5 -3590 2635 -3590 { lab=clk}
N 2750 -3477.5 2750 -3460 { lab=GND}
N 2750 -3477.5 2752.5 -3477.5 { lab=GND}
N 2752.5 -3185 2752.5 -3180 { lab=GND}
N 2752.5 -3202.5 2752.5 -3185 { lab=GND}
N 2622.5 -3325 2635 -3325 { lab=A}
N 2622.5 -3255 2635 -3255 { lab=B14}
N 2752.5 -3205 2752.5 -3202.5 { lab=GND}
N 2855 -3295 2870 -3295 { lab=Q14}
N 2745 -3405 2745 -3390 { lab=VDD}
N 2622.5 -3292.5 2635 -3292.5 { lab=clk}
N 2750 -3180 2750 -3162.5 { lab=GND}
N 2750 -3180 2752.5 -3180 { lab=GND}
N 2730 -3695 2745 -3695 {}
N 2737.5 -3492.5 2752.5 -3492.5 {}
N 2730 -3397.5 2745 -3397.5 {}
N 2737.5 -3195 2752.5 -3195 {}
N 872.5 -5695 872.5 -5685 { lab=GND}
N 872.5 -5775 872.5 -5755 { lab=B12}
N 952.5 -5695 952.5 -5685 { lab=GND}
N 952.5 -5775 952.5 -5755 { lab=B11}
N 720 -5695 720 -5685 { lab=GND}
N 720 -5775 720 -5755 { lab=B14}
N 800 -5695 800 -5685 { lab=GND}
N 800 -5775 800 -5755 { lab=B13}
N 770 -5302.5 770 -5292.5 { lab=GND}
N 770 -5382.5 770 -5362.5 { lab=A}
N 770 -5127.5 770 -5117.5 { lab=GND}
N 770 -5207.5 770 -5187.5 { lab=A}
N 770 -4972.5 770 -4962.5 { lab=GND}
N 770 -5052.5 770 -5032.5 { lab=A}
N 770 -4810 770 -4800 { lab=GND}
N 770 -4890 770 -4870 { lab=A}
N 770 -4647.5 770 -4637.5 { lab=GND}
N 770 -4727.5 770 -4707.5 { lab=A}
N 770 -4477.5 770 -4467.5 { lab=GND}
N 770 -4557.5 770 -4537.5 { lab=A}
N 770 -4337.5 770 -4327.5 { lab=GND}
N 770 -4417.5 770 -4397.5 { lab=A}
N 770 -4180 770 -4170 { lab=GND}
N 770 -4260 770 -4240 { lab=A}
N 770 -4030 770 -4020 { lab=GND}
N 770 -4110 770 -4090 { lab=A}
N 770 -3852.5 770 -3842.5 { lab=GND}
N 770 -3932.5 770 -3912.5 { lab=A}
N 770 -3660 770 -3650 { lab=GND}
N 770 -3740 770 -3720 { lab=A}
N 770 -3475 770 -3465 { lab=GND}
N 770 -3555 770 -3535 { lab=A}
N 770 -3335 770 -3325 { lab=GND}
N 770 -3415 770 -3395 { lab=A}
N 770 -3177.5 770 -3167.5 { lab=GND}
N 770 -3257.5 770 -3237.5 { lab=A}
N 770 -3027.5 770 -3017.5 { lab=GND}
N 770 -3107.5 770 -3087.5 { lab=A}
N 770 -2850 770 -2840 { lab=GND}
N 770 -2930 770 -2910 { lab=A}
N 770 -2657.5 770 -2647.5 { lab=GND}
N 770 -2737.5 770 -2717.5 { lab=A}
C {devices/gnd.sym} 550 -5455 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 550 -5545 0 0 {name=l16 sig_type=std_logic lab=clk}
C {devices/vsource.sym} 550 -5495 0 0 {name=V5 value="pulse 0 1.8 2u .1n .1n 2u 4u"}
C {devices/code.sym} 490 -5360 0 0 {name=STIMULI1 
only_toplevel=true
place=end
value="
.temp 25
vvcc vcc 0 1.8
vvss vss 0 0
.control
tran 0.5u 130u
plot Q1 Q2+2 Q3+4 Q4+6 Q5+8 Q6+10 Q7+12 Q8+14 Q9+16 Q10+18 Q11+20 Q12+22 Q13+24 Q14+28 Q15+30 Q16+32 Q17+34 Q18+36 
meas tran x find t(Q1) when v(Q1)=1.8
meas tran x find t(Q2) when v(Q2)=1.8
meas tran x find t(Q3) when v(Q3)=1.8
meas tran x find t(Q4) when v(Q4)=1.8
meas tran x find t(Q5) when v(Q5)=1.8
meas tran x find t(Q6) when v(Q6)=1.8
meas tran x find t(Q7) when v(Q7)=1.8
meas tran x find t(Q8) when v(Q8)=1.8
meas tran x find t(Q9) when v(Q9)=1.8
meas tran x find t(Q10) when v(Q10)=1.8
meas tran x find t(Q11) when v(Q11)=1.8
meas tran x find t(Q12) when v(Q12)=1.8
meas tran x find t(Q13) when v(Q13)=1.8
meas tran x find t(Q14) when v(Q14)=1.8
meas tran x find t(Q15) when v(Q15)=1.8
meas tran x find t(Q16) when v(Q16)=1.8
meas tran x find t(Q17) when v(Q17)=1.8
meas tran x find t(Q18) when v(Q18)=1.8

.endc
"}
C {devices/code.sym} 350 -5360 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand3/sky130_fd_sc_hd__nand3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_4.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_2.spice

.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor3/sky130_fd_sc_hd__nor3_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dlrbn/sky130_fd_sc_hd__dlrbn_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a31o/sky130_fd_sc_hd__a31o_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a222oi/sky130_fd_sc_hd__a222oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a221oi/sky130_fd_sc_hd__a221oi_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/a221oi/sky130_fd_sc_hd__a221oi_4.spice

.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_1.spice
.include ~/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/o221ai/sky130_fd_sc_hd__o221ai_4.spice


"}
C {devices/vsource.sym} 380 -5507.5 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} 380 -5467.5 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} 380 -5557.5 0 0 {name=l54 sig_type=std_logic lab=VDD
}
C {devices/lab_pin.sym} 2145 -5352.5 0 0 {name=l1 sig_type=std_logic lab=A1
}
C {devices/lab_pin.sym} 2145 -5282.5 0 0 {name=l2 sig_type=std_logic lab=B1
}
C {devices/lab_pin.sym} 2145 -5320 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2267.5 -5432.5 0 0 {name=l4 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2272.5 -5190 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 2392.5 -5322.5 2 0 {name=l6 sig_type=std_logic lab=Q1
}
C {devices/lab_pin.sym} 2147.5 -5062.5 0 0 {name=l7 sig_type=std_logic lab=A2
}
C {devices/lab_pin.sym} 2147.5 -4992.5 0 0 {name=l20 sig_type=std_logic lab=B2
}
C {devices/lab_pin.sym} 2147.5 -5030 0 0 {name=l21 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2270 -5142.5 0 0 {name=l22 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2275 -4900 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 2395 -5032.5 2 0 {name=l24 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 2155 -4770 0 0 {name=l25 sig_type=std_logic lab=A3
}
C {devices/lab_pin.sym} 2155 -4700 0 0 {name=l26 sig_type=std_logic lab=B3
}
C {devices/lab_pin.sym} 2155 -4737.5 0 0 {name=l27 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2277.5 -4850 0 0 {name=l28 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2282.5 -4607.5 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} 2402.5 -4740 2 0 {name=l30 sig_type=std_logic lab=Q3
}
C {devices/lab_pin.sym} 2152.5 -4452.5 0 0 {name=l31 sig_type=std_logic lab=A4
}
C {devices/lab_pin.sym} 2152.5 -4382.5 0 0 {name=l32 sig_type=std_logic lab=B4
}
C {devices/lab_pin.sym} 2152.5 -4420 0 0 {name=l33 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2275 -4532.5 0 0 {name=l34 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2280 -4290 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 2400 -4422.5 2 0 {name=l36 sig_type=std_logic lab=Q4
}
C {devices/lab_pin.sym} 2152.5 -4137.5 0 0 {name=l37 sig_type=std_logic lab=A5
}
C {devices/lab_pin.sym} 2152.5 -4067.5 0 0 {name=l38 sig_type=std_logic lab=B5
}
C {devices/lab_pin.sym} 2152.5 -4105 0 0 {name=l39 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2275 -4217.5 0 0 {name=l40 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2280 -3975 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} 2400 -4107.5 2 0 {name=l42 sig_type=std_logic lab=Q5
}
C {devices/lab_pin.sym} 2160 -3817.5 0 0 {name=l43 sig_type=std_logic lab=A6
}
C {devices/lab_pin.sym} 2160 -3747.5 0 0 {name=l44 sig_type=std_logic lab=B6
}
C {devices/lab_pin.sym} 2160 -3785 0 0 {name=l55 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2282.5 -3897.5 0 0 {name=l56 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2287.5 -3655 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} 2407.5 -3787.5 2 0 {name=l58 sig_type=std_logic lab=Q6
}
C {devices/lab_pin.sym} 2170 -3500 0 0 {name=l59 sig_type=std_logic lab=A7
}
C {devices/lab_pin.sym} 2170 -3430 0 0 {name=l60 sig_type=std_logic lab=B7
}
C {devices/lab_pin.sym} 2170 -3467.5 0 0 {name=l61 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2292.5 -3580 0 0 {name=l62 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2297.5 -3337.5 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 2417.5 -3470 2 0 {name=l64 sig_type=std_logic lab=Q7
}
C {devices/lab_pin.sym} 2170 -3202.5 0 0 {name=l65 sig_type=std_logic lab=A8
}
C {devices/lab_pin.sym} 2170 -3132.5 0 0 {name=l66 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} 2170 -3170 0 0 {name=l67 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2292.5 -3282.5 0 0 {name=l68 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2297.5 -3040 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 2417.5 -3172.5 2 0 {name=l70 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 2170 -2802.5 0 0 {name=l71 sig_type=std_logic lab=A9
}
C {devices/lab_pin.sym} 2170 -2732.5 0 0 {name=l72 sig_type=std_logic lab=B9
}
C {devices/lab_pin.sym} 2170 -2770 0 0 {name=l73 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2292.5 -2882.5 0 0 {name=l74 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2297.5 -2640 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 2417.5 -2772.5 2 0 {name=l76 sig_type=std_logic lab=Q9
}
C {devices/lab_pin.sym} 2170 -2505 0 0 {name=l77 sig_type=std_logic lab=A10
}
C {devices/lab_pin.sym} 2170 -2435 0 0 {name=l78 sig_type=std_logic lab=B10
}
C {devices/lab_pin.sym} 2170 -2472.5 0 0 {name=l79 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2292.5 -2585 0 0 {name=l80 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2297.5 -2342.5 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 2417.5 -2475 2 0 {name=l82 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 2172.5 -2155 0 0 {name=l91 sig_type=std_logic lab=A11
}
C {devices/lab_pin.sym} 2172.5 -2085 0 0 {name=l92 sig_type=std_logic lab=B11
}
C {devices/lab_pin.sym} 2172.5 -2122.5 0 0 {name=l93 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2295 -2235 0 0 {name=l94 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2300 -1992.5 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} 2420 -2125 2 0 {name=l96 sig_type=std_logic lab=Q11
}
C {devices/lab_pin.sym} 2172.5 -1857.5 0 0 {name=l97 sig_type=std_logic lab=A12
}
C {devices/lab_pin.sym} 2172.5 -1787.5 0 0 {name=l98 sig_type=std_logic lab=B12}
C {devices/lab_pin.sym} 2172.5 -1825 0 0 {name=l99 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2295 -1937.5 0 0 {name=l100 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2300 -1695 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} 2420 -1827.5 2 0 {name=l102 sig_type=std_logic lab=Q12}
C {devices/vsource.sym} 1535 -5722.5 0 0 {name=V16 value=0.7}
C {devices/vsource.sym} 770 -5495 0 0 {name=V17 value="pwl 0 0 12.5u 0 12.5u 0.01 22.5u 0.01 22.5u 0.02 32.5u 0.02 32.5u 0.03 42.5u 0.03 42.5u 0.04 52.5u 0.04 52.5u 0.05 62.5u 0.05 62.5u 0.06 72.5u 0.06 72.5u 0.07 82.5u 0.07 82.5u 0.08 92.5u 0.08 92.5u 0.09 102.5u 0.09 102.5u 0.1 112.5u 0.1 "}
C {devices/gnd.sym} 770 -5455 0 0 {name=l104 lab=GND}
C {devices/gnd.sym} 1535 -5682.5 0 0 {name=l105 lab=GND}
C {devices/lab_pin.sym} 1535 -5772.5 0 0 {name=l106 sig_type=std_logic lab=B8
}
C {devices/lab_pin.sym} 770 -5545 0 0 {name=l107 sig_type=std_logic lab=A1
}
C {devices/vsource.sym} 1622.5 -5722.5 0 0 {name=V19 value=0.6}
C {devices/gnd.sym} 1622.5 -5682.5 0 0 {name=l109 lab=GND}
C {devices/lab_pin.sym} 1622.5 -5772.5 0 0 {name=l110 sig_type=std_logic lab=B7
}
C {devices/vsource.sym} 1702.5 -5722.5 0 0 {name=V20 value=0.5}
C {devices/gnd.sym} 1702.5 -5682.5 0 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 1702.5 -5772.5 0 0 {name=l112 sig_type=std_logic lab=B6
}
C {devices/vsource.sym} 1787.5 -5720 0 0 {name=V21 value=0.4}
C {devices/gnd.sym} 1787.5 -5680 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} 1787.5 -5770 0 0 {name=l114 sig_type=std_logic lab=B5
}
C {devices/vsource.sym} 1865 -5717.5 0 0 {name=V22 value=0.3}
C {devices/gnd.sym} 1865 -5677.5 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} 1865 -5767.5 0 0 {name=l116 sig_type=std_logic lab=B4
}
C {devices/vsource.sym} 1952.5 -5717.5 0 0 {name=V23 value=0.2}
C {devices/gnd.sym} 1952.5 -5677.5 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 1952.5 -5767.5 0 0 {name=l118 sig_type=std_logic lab=B3
}
C {devices/vsource.sym} 2032.5 -5717.5 0 0 {name=V24 value=0.1}
C {devices/gnd.sym} 2032.5 -5677.5 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} 2032.5 -5767.5 0 0 {name=l120 sig_type=std_logic lab=B2
}
C {devices/vsource.sym} 2117.5 -5715 0 0 {name=V25 value=0}
C {devices/gnd.sym} 2117.5 -5675 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} 2117.5 -5765 0 0 {name=l122 sig_type=std_logic lab=B1
}
C {devices/vsource.sym} 1362.5 -5722.5 0 0 {name=V27 value=0.9}
C {devices/gnd.sym} 1362.5 -5682.5 0 0 {name=l185 lab=GND}
C {devices/lab_pin.sym} 1362.5 -5772.5 0 0 {name=l186 sig_type=std_logic lab=B10
}
C {devices/vsource.sym} 1450 -5722.5 0 0 {name=V28 value=0.8}
C {devices/gnd.sym} 1450 -5682.5 0 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} 1450 -5772.5 0 0 {name=l188 sig_type=std_logic lab=B9
}
C {devices/vsource.sym} 1187.5 -5725 0 0 {name=V30 value=1.1}
C {devices/gnd.sym} 1187.5 -5685 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} 1187.5 -5775 0 0 {name=l192 sig_type=std_logic lab=B12
}
C {devices/vsource.sym} 1267.5 -5725 0 0 {name=V31 value=1.0}
C {devices/gnd.sym} 1267.5 -5685 0 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} 1267.5 -5775 0 0 {name=l194 sig_type=std_logic lab=B11
}
C {devices/vsource.sym} 1035 -5725 0 0 {name=V1 value=1.3}
C {devices/gnd.sym} 1035 -5685 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 1035 -5775 0 0 {name=l9 sig_type=std_logic lab=B14
}
C {devices/vsource.sym} 1115 -5725 0 0 {name=V2 value=1.2}
C {devices/gnd.sym} 1115 -5685 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1115 -5775 0 0 {name=l12 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 2622.5 -4935 0 0 {name=l13 sig_type=std_logic lab=A13
}
C {devices/lab_pin.sym} 2622.5 -4865 0 0 {name=l14 sig_type=std_logic lab=B13
}
C {devices/lab_pin.sym} 2622.5 -4902.5 0 0 {name=l15 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -5015 0 0 {name=l17 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -4772.5 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 2870 -4905 2 0 {name=l19 sig_type=std_logic lab=Q13
}
C {devices/lab_pin.sym} 2622.5 -4637.5 0 0 {name=l45 sig_type=std_logic lab=A14
}
C {devices/lab_pin.sym} 2622.5 -4567.5 0 0 {name=l46 sig_type=std_logic lab=B14}
C {devices/lab_pin.sym} 2622.5 -4605 0 0 {name=l47 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -4717.5 0 0 {name=l48 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -4475 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 2870 -4607.5 2 0 {name=l50 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 2622.5 -4285 0 0 {name=l51 sig_type=std_logic lab=A15
}
C {devices/lab_pin.sym} 2622.5 -4215 0 0 {name=l52 sig_type=std_logic lab=B15
}
C {devices/lab_pin.sym} 2622.5 -4252.5 0 0 {name=l83 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -4365 0 0 {name=l84 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -4122.5 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} 2870 -4255 2 0 {name=l86 sig_type=std_logic lab=Q15
}
C {devices/lab_pin.sym} 2622.5 -3987.5 0 0 {name=l87 sig_type=std_logic lab=A16
}
C {devices/lab_pin.sym} 2622.5 -3917.5 0 0 {name=l88 sig_type=std_logic lab=B16}
C {devices/lab_pin.sym} 2622.5 -3955 0 0 {name=l89 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -4067.5 0 0 {name=l90 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -3825 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} 2870 -3957.5 2 0 {name=l108 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} 2622.5 -3622.5 0 0 {name=l123 sig_type=std_logic lab=A17
}
C {devices/lab_pin.sym} 2622.5 -3552.5 0 0 {name=l124 sig_type=std_logic lab=B17
}
C {devices/lab_pin.sym} 2622.5 -3590 0 0 {name=l125 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -3702.5 0 0 {name=l126 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -3460 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} 2870 -3592.5 2 0 {name=l128 sig_type=std_logic lab=Q17
}
C {devices/lab_pin.sym} 2622.5 -3325 0 0 {name=l129 sig_type=std_logic lab=A18
}
C {devices/lab_pin.sym} 2622.5 -3255 0 0 {name=l130 sig_type=std_logic lab=B18}
C {devices/lab_pin.sym} 2622.5 -3292.5 0 0 {name=l131 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 2745 -3405 0 0 {name=l132 sig_type=std_logic lab=VDD
}
C {devices/gnd.sym} 2750 -3162.5 0 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} 2870 -3295 2 0 {name=l134 sig_type=std_logic lab=Q18}
C {devices/vsource.sym} 872.5 -5725 0 0 {name=V3 value=1.5}
C {devices/gnd.sym} 872.5 -5685 0 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} 872.5 -5775 0 0 {name=l136 sig_type=std_logic lab=B16
}
C {devices/vsource.sym} 952.5 -5725 0 0 {name=V4 value=1.4}
C {devices/gnd.sym} 952.5 -5685 0 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} 952.5 -5775 0 0 {name=l138 sig_type=std_logic lab=B15
}
C {devices/vsource.sym} 720 -5725 0 0 {name=V6 value=1.7}
C {devices/gnd.sym} 720 -5685 0 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} 720 -5775 0 0 {name=l140 sig_type=std_logic lab=B18
}
C {devices/vsource.sym} 800 -5725 0 0 {name=V7 value=1.6}
C {devices/gnd.sym} 800 -5685 0 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} 800 -5775 0 0 {name=l142 sig_type=std_logic lab=B17
}
C {devices/vsource.sym} 770 -5332.5 0 0 {name=V8 value="pwl 0 0.1 12.5u 0.1 12.5u 0.11 22.5u 0.11 22.5u 0.12 32.5u 0.12 32.5u 0.13 42.5u 0.13 42.5u 0.14 52.5u 0.14 52.5u 0.15 62.5u 0.15 62.5u 0.16 72.5u 0.16 72.5u 0.17 82.5u 0.17 82.5u 0.18 92.5u 0.18 92.5u 0.19 102.5u 0.19 102.5u 0.2 112.5u 0.2 "}
C {devices/gnd.sym} 770 -5292.5 0 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} 770 -5382.5 0 0 {name=l144 sig_type=std_logic lab=A2
}
C {devices/vsource.sym} 770 -5157.5 0 0 {name=V9 value="pwl 0 0.2 12.5u 0.2 12.5u 0.21 22.5u 0.21 22.5u 0.22 32.5u 0.22 32.5u 0.23 42.5u 0.23 42.5u 0.24 52.5u 0.24 52.5u 0.25 62.5u 0.25 62.5u 0.26 72.5u 0.26 72.5u 0.27 82.5u 0.27 82.5u 0.28 92.5u 0.28 92.5u 0.29 102.5u 0.29 102.5u 0.3 112.5u 0.3"}
C {devices/gnd.sym} 770 -5117.5 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} 770 -5207.5 0 0 {name=l146 sig_type=std_logic lab=A3}
C {devices/vsource.sym} 770 -5002.5 0 0 {name=V10 value="pwl 0 0.3 12.5u 0.3 12.5u 0.31 22.5u 0.31 22.5u 0.32 32.5u 0.32 32.5u 0.33 42.5u 0.33 42.5u 0.34 52.5u 0.34 52.5u 0.35 62.5u 0.35 62.5u 0.36 72.5u 0.36 72.5u 0.37 82.5u 0.37 82.5u 0.38 92.5u 0.38 92.5u 0.39 102.5u 0.39 102.5u 0.4 112.5u 0.4"}
C {devices/gnd.sym} 770 -4962.5 0 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} 770 -5052.5 0 0 {name=l148 sig_type=std_logic lab=A4
}
C {devices/vsource.sym} 770 -4840 0 0 {name=V12 value="pwl 0 0.4 12.5u 0.4 12.5u 0.41 22.5u 0.41 22.5u 0.42 32.5u 0.42 32.5u 0.43 42.5u 0.43 42.5u 0.44 52.5u 0.44 52.5u 0.45 62.5u 0.45 62.5u 0.46 72.5u 0.46 72.5u 0.47 82.5u 0.47 82.5u 0.48 92.5u 0.48 92.5u 0.49 102.5u 0.49 102.5u 0.5 112.5u 0.5 "}
C {devices/gnd.sym} 770 -4800 0 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} 770 -4890 0 0 {name=l150 sig_type=std_logic lab=A5
}
C {devices/vsource.sym} 770 -4677.5 0 0 {name=V13 value="pwl 0 0.5 12.5u 0.5 12.5u 0.51 22.5u 0.51 22.5u 0.52 32.5u 0.52 32.5u 0.53 42.5u 0.53 42.5u 0.54 52.5u 0.54 52.5u 0.55 62.5u 0.55 62.5u 0.56 72.5u 0.56 72.5u 0.57 82.5u 0.57 82.5u 0.58 92.5u 0.58 92.5u 0.59 102.5u 0.59 102.5u 0.6 112.5u 0.6 "}
C {devices/gnd.sym} 770 -4637.5 0 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} 770 -4727.5 0 0 {name=l152 sig_type=std_logic lab=A6
}
C {devices/vsource.sym} 770 -4507.5 0 0 {name=V14 value="pwl 0 0.6 12.5u 0.6 12.5u 0.61 22.5u 0.61 22.5u 0.62 32.5u 0.62 32.5u 0.63 42.5u 0.63 42.5u 0.64 52.5u 0.64 52.5u 0.65 62.5u 0.65 62.5u 0.66 72.5u 0.66 72.5u 0.67 82.5u 0.67 82.5u 0.68 92.5u 0.68 92.5u 0.69 102.5u 0.69 102.5u 0.7 112.5u 0.7 "}
C {devices/gnd.sym} 770 -4467.5 0 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} 770 -4557.5 0 0 {name=l154 sig_type=std_logic lab=A7
}
C {devices/vsource.sym} 770 -4367.5 0 0 {name=V15 value="pwl 0 0.7 12.5u 0.7 12.5u 0.71 22.5u 0.71 22.5u 0.72 32.5u 0.72 32.5u 0.73 42.5u 0.73 42.5u 0.74 52.5u 0.74 52.5u 0.75 62.5u 0.75 62.5u 0.76 72.5u 0.76 72.5u 0.77 82.5u 0.77 82.5u 0.78 92.5u 0.78 92.5u 0.79 102.5u 0.79 102.5u 0.8 112.5u 0.8 "}
C {devices/gnd.sym} 770 -4327.5 0 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} 770 -4417.5 0 0 {name=l156 sig_type=std_logic lab=A8
}
C {devices/vsource.sym} 770 -4210 0 0 {name=V18 value="pwl 0 .8 12.5u 0.8 12.5u 0.81 22.5u 0.81 22.5u 0.82 32.5u 0.82 32.5u 0.83 42.5u 0.83 42.5u 0.84 52.5u 0.84 52.5u 0.85 62.5u 0.85 62.5u 0.86 72.5u 0.86 72.5u 0.87 82.5u 0.87 82.5u 0.88 92.5u 0.88 92.5u 0.89 102.5u 0.89 102.5u 0.9 112.5u 0.9 "}
C {devices/gnd.sym} 770 -4170 0 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} 770 -4260 0 0 {name=l158 sig_type=std_logic lab=A9
}
C {devices/vsource.sym} 770 -4060 0 0 {name=V26 value="pwl 0 0.9 12.5u 0.9 12.5u 0.91 22.5u 0.91 22.5u 0.92 32.5u 0.92 32.5u 0.93 42.5u 0.93 42.5u 0.94 52.5u 0.94 52.5u 0.95 62.5u 0.95 62.5u 0.96 72.5u 0.96 72.5u 0.97 82.5u 0.97 82.5u 0.98 92.5u 0.98 92.5u 0.99 102.5u 0.99 102.5u 1.0 112.5u 1.0 "}
C {devices/gnd.sym} 770 -4020 0 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} 770 -4110 0 0 {name=l160 sig_type=std_logic lab=A10
}
C {devices/vsource.sym} 770 -3882.5 0 0 {name=V29 value="pwl 0 1.0 12.5u 1.0 12.5u 1.01 22.5u 1.01 22.5u 1.02 32.5u 1.02 32.5u 1.03 42.5u 1.03 42.5u 1.04 52.5u 1.04 52.5u 1.05 62.5u 1.05 62.5u 1.06 72.5u 1.06 72.5u 1.07 82.5u 1.07 82.5u 1.08 92.5u 1.08 92.5u 1.09 102.5u 1.09 102.5u 1.1 112.5u 1.1 "}
C {devices/gnd.sym} 770 -3842.5 0 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} 770 -3932.5 0 0 {name=l162 sig_type=std_logic lab=A11
}
C {devices/vsource.sym} 770 -3690 0 0 {name=V32 value="pwl 0 1.1 12.5u 1.1 12.5u 1.11 22.5u 1.11 22.5u 1.12 32.5u 1.12 32.5u 1.13 42.5u 1.13 42.5u 1.14 52.5u 1.14 52.5u 1.15 62.5u 1.15 62.5u 1.16 72.5u 1.16 72.5u 1.17 82.5u 1.17 82.5u 1.18 92.5u 1.18 92.5u 1.19 102.5u 1.19 102.5u 1.2 112.5u 1.2 "}
C {devices/gnd.sym} 770 -3650 0 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} 770 -3740 0 0 {name=l164 sig_type=std_logic lab=A12
}
C {devices/gnd.sym} 770 -3465 0 0 {name=l165 lab=GND}
C {devices/lab_pin.sym} 770 -3555 0 0 {name=l166 sig_type=std_logic lab=A13
}
C {devices/gnd.sym} 770 -3325 0 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} 770 -3415 0 0 {name=l168 sig_type=std_logic lab=A14
}
C {devices/gnd.sym} 770 -3167.5 0 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} 770 -3257.5 0 0 {name=l170 sig_type=std_logic lab=A15
}
C {devices/gnd.sym} 770 -3017.5 0 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} 770 -3107.5 0 0 {name=l172 sig_type=std_logic lab=A16
}
C {devices/gnd.sym} 770 -2840 0 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} 770 -2930 0 0 {name=l174 sig_type=std_logic lab=A17
}
C {devices/gnd.sym} 770 -2647.5 0 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} 770 -2737.5 0 0 {name=l176 sig_type=std_logic lab=A18
}
C {devices/vsource.sym} 770 -3505 0 0 {name=V33 value="pwl 0 1.2 12.5u 1.2 12.5u 1.21 22.5u 1.21 22.5u 1.22 32.5u 1.22 32.5u 1.23 42.5u 1.23 42.5u 1.24 52.5u 1.24 52.5u 1.25 62.5u 1.25 62.5u 1.26 72.5u 1.26 72.5u 1.27 82.5u 1.27 82.5u 1.28 92.5u 1.28 92.5u 1.29 102.5u 1.29 102.5u 1.3 112.5u 1.3 "}
C {devices/vsource.sym} 770 -3365 0 0 {name=V34 value="pwl 0 1.3 12.5u 1.3 12.5u 1.31 22.5u 1.31 22.5u 1.32 32.5u 1.32 32.5u 1.33 42.5u 1.33 42.5u 1.34 52.5u 1.34 52.5u 1.35 62.5u 1.35 62.5u 1.36 72.5u 1.36 72.5u 1.37 82.5u 1.37 82.5u 1.38 92.5u 1.38 92.5u 1.39 102.5u 1.39 102.5u 1.4 112.5u 1.4 "}
C {devices/vsource.sym} 770 -3207.5 0 0 {name=V35 value="pwl 0 1.4 12.5u 1.4 12.5u 1.41 22.5u 1.41 22.5u 1.42 32.5u 1.42 32.5u 1.43 42.5u 1.43 42.5u 1.44 52.5u 1.44 52.5u 1.45 62.5u 1.45 62.5u 1.46 72.5u 1.46 72.5u 1.47 82.5u 1.47 82.5u 1.48 92.5u 1.48 92.5u 1.49 102.5u 1.49 102.5u 1.5 112.5u 1.5 "}
C {devices/vsource.sym} 770 -3057.5 0 0 {name=V36 value="pwl 0 1.5 12.5u 1.5 12.5u 1.51 22.5u 1.51 22.5u 1.52 32.5u 1.52 32.5u 1.53 42.5u 1.53 42.5u 1.54 52.5u 1.54 52.5u 1.55 62.5u 1.55 62.5u 1.56 72.5u 1.56 72.5u 1.57 82.5u 1.57 82.5u 1.58 92.5u 1.58 92.5u 1.59 102.5u 1.59 102.5u 1.6 112.5u 1.6 "}
C {devices/vsource.sym} 770 -2880 0 0 {name=V37 value="pwl 0 1.6 12.5u 1.6 12.5u 1.61 22.5u 1.61 22.5u 1.62 32.5u 1.62 32.5u 1.63 42.5u 1.63 42.5u 1.64 52.5u 1.64 52.5u 1.65 62.5u 1.65 62.5u 1.66 72.5u 1.66 72.5u 1.67 82.5u 1.67 82.5u 1.68 92.5u 1.68 92.5u 1.69 102.5u 1.69 102.5u 1.7 112.5u 1.7 "}
C {devices/vsource.sym} 770 -2687.5 0 0 {name=V38 value="pwl 0 1.7 12.5u 1.7 12.5u 1.71 22.5u 1.71 22.5u 1.72 32.5u 1.72 32.5u 1.73 42.5u 1.73 42.5u 1.74 52.5u 1.74 52.5u 1.75 62.5u 1.75 62.5u 1.76 72.5u 1.76 72.5u 1.77 82.5u 1.77 82.5u 1.78 92.5u 1.78 92.5u 1.79 102.5u 1.79 102.5u 1.8 112.5u 1.8 "}
C {cmpoai_all__.sym} 23871080 159910130 0 0 {name=x1}
C {cmpoai_all__.sym} 23871082.5 159910420 0 0 {name=x2}
C {cmpoai_all__.sym} 23871090 159910712.5 0 0 {name=x3}
C {cmpoai_all__.sym} 23871087.5 159911030 0 0 {name=x4}
C {cmpoai_all__.sym} 23871087.5 159911345 0 0 {name=x5}
C {cmpoai_all__.sym} 23871095 159911665 0 0 {name=x6}
C {cmpoai_all__.sym} 23871105 159911982.5 0 0 {name=x7}
C {cmpoai_all__.sym} 23871105 159912280 0 0 {name=x8}
C {cmpoai_all__.sym} 23871105 159912680 0 0 {name=x9}
C {cmpoai_all__.sym} 23871105 159912977.5 0 0 {name=x10}
C {cmpoai_all__.sym} 23871107.5 159913327.5 0 0 {name=x11}
C {cmpoai_all__.sym} 23871107.5 159913625 0 0 {name=x12}
C {cmpoai_all__.sym} 23871557.5 159910547.5 0 0 {name=x13}
C {cmpoai_all__.sym} 23871557.5 159910845 0 0 {name=x14}
C {cmpoai_all__.sym} 23871557.5 159911197.5 0 0 {name=x15}
C {cmpoai_all__.sym} 23871557.5 159911495 0 0 {name=x16}
C {cmpoai_all__.sym} 23871557.5 159911860 0 0 {name=x17}
C {cmpoai_all__.sym} 23871557.5 159912157.5 0 0 {name=x18}
